$ Spice netlist generated by v2lvs
$ v2020.2_14.12    Thu Apr 2 15:39:14 PDT 2020
.INCLUDE "tpz973gv_lvs.spi"
.INCLUDE "tsmc18_lvs.spi"
*.BUSDELIMITER [

.SUBCKT CONV_DW_cmp_0 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] TC GE_LT GE_GT_EQ
+ GE_LT_GT_LE EQ_NE p1 p2 FE_OFN150_register_7__18 _register_7_18
+ _register_7_10 _register_7_16 n5649 FE_OFN5783_register_7__9
+ FE_OFN5853_FE_DBTN21_N1711
XFE_RC_788_0 OAI21XL $PINS A0=n1448 A1=n1469 B0=n1468 Y=n1461
XFE_RC_787_0 OAI21XL $PINS A0=n1452 A1=n1459 B0=n1458 Y=n1443
XU664 AND2X2 $PINS A=B[3] B=A[3] Y=n1456
XU622 AOI32X1 $PINS A0=_register_7_18 A1=n1493 A2=n1479 B0=n1495 B1=A[19]
+ Y=n1477
XU624 AOI32X1 $PINS A0=A[6] A1=n1487 A2=n1460 B0=n1486 B1=A[7] Y=n1458
XU625 AOI32XL $PINS A0=n1455 A1=n1488 A2=A[4] B0=A[5] B1=n1491 Y=n1459
XU626 AOI32X1 $PINS A0=n1449 A1=n1485 A2=A[8] B0=FE_OFN5783_register_7__9
+ B1=n1498 Y=n1469
XU627 OAI221XL $PINS A0=A[4] A1=n1488 B0=n1453 B1=n1454 C0=n1455 Y=n1451
XU628 OR2XL $PINS A=A[19] B=n1495 Y=n1479
XU629 OAI33X1 $PINS A0=n1492 A1=n1437 A2=n1438 B0=n1439 B1=n1440 B2=n1441
+ Y=GE_LT_GT_LE
XU630 OAI32X1 $PINS A0=n1442 A1=n1443 A2=n1444 B0=n1445 B1=n1442 Y=n1441
XU631 NOR3BX1 $PINS AN=n1446 B=n1447 C=n1448 Y=n1445
XU633 OAI2BB1X1 $PINS A0N=n1461 A1N=n1446 B0=n1462 Y=n1442
XU634 OR3XL $PINS A=n1438 B=n1437 C=n1472 Y=n1439
XU635 OAI32X1 $PINS A0=A[2] A1=B[2] A2=n1456 B0=B[3] B1=A[3] Y=n1454
XU636 AOI211X1 $PINS A0=n1450 A1=n1482 B0=n1451 C0=n1452 Y=n1444
XU637 INVX1 $PINS A=n1454 Y=n1482
XU638 OAI22X1 $PINS A0=n1463 A1=n1464 B0=n1465 B1=n1463 Y=n1462
XU639 OAI32X1 $PINS A0=A[12] A1=B[12] A2=n1466 B0=B[13] B1=p1 Y=n1464
XU640 OAI32X1 $PINS A0=A[14] A1=B[14] A2=n1467 B0=B[15] B1=p2 Y=n1463
XU642 NOR2BXL $PINS AN=B[15] B=A[15] Y=n1467
XU643 NAND2X1 $PINS A=n1473 B=n1474 Y=n1438
XU644 NOR4X1 $PINS A=B[31] B=B[30] C=B[29] D=B[28] Y=n1473
XU646 AOI32XL $PINS A0=_register_7_10 A1=n1490 A2=n1470 B0=n1496 B1=A[11]
+ Y=n1468
XU647 INVX1 $PINS A=B[9] Y=n1498
XU648 NAND2X1 $PINS A=n1475 B=n1476 Y=n1437
XU649 NOR4X1 $PINS A=B[23] B=B[22] C=B[21] D=B[20] Y=n1475
XU650 NOR4X1 $PINS A=B[27] B=B[26] C=B[25] D=B[24] Y=n1476
XU651 INVX1 $PINS A=B[11] Y=n1496
XU652 INVX1 $PINS A=B[7] Y=n1486
XU653 INVX1 $PINS A=B[6] Y=n1487
XU654 INVX1 $PINS A=B[1] Y=n1489
XU655 OR2XL $PINS A=A[11] B=n1496 Y=n1470
XU656 OR2XL $PINS A=A[7] B=n1486 Y=n1460
XU657 AOI211X1 $PINS A0=A[12] A1=B[12] B0=n1466 C0=n1497 Y=n1446
XU658 INVX1 $PINS A=n1465 Y=n1497
XU659 INVX1 $PINS A=B[5] Y=n1491
XU660 OAI21XL $PINS A0=_register_7_10 A1=n1490 B0=n1470 Y=n1448
XU661 AOI21X1 $PINS A0=A[14] A1=B[14] B0=n1467 Y=n1465
XU662 OAI21XL $PINS A0=_register_7_18 A1=n1493 B0=n1479 Y=n1472
XU663 INVX1 $PINS A=B[18] Y=n1493
XU665 INVX1 $PINS A=B[16] Y=n1499
XU666 NOR2BXL $PINS AN=B[13] B=A[13] Y=n1466
XU667 INVX1 $PINS A=B[19] Y=n1495
XU669 NAND2BXL $PINS AN=FE_OFN5783_register_7__9 B=B[9] Y=n1449
XU670 INVX1 $PINS A=B[17] Y=n1494
XU671 NAND2BXL $PINS AN=A[5] B=B[5] Y=n1455
XU672 INVX1 $PINS A=B[8] Y=n1485
XU673 OAI21XL $PINS A0=A[8] A1=n1485 B0=n1449 Y=n1447
XU674 AOI21X1 $PINS A0=B[2] A1=A[2] B0=n1456 Y=n1453
XU675 INVX1 $PINS A=B[10] Y=n1490
XU677 OAI21XL $PINS A0=n5649 A1=n1499 B0=n1471 Y=n1440
XU678 INVX1 $PINS A=B[4] Y=n1488
XU679 OR2XL $PINS A=A[17] B=n1494 Y=n1471
XU680 INVX1 $PINS A=n1414 Y=n1492
XU681 OAI21XL $PINS A0=n1478 A1=n1472 B0=n1477 Y=n1414
XU682 AOI32XL $PINS A0=n5649 A1=n1499 A2=n1471 B0=n1494 B1=A[17] Y=n1478
XU683 NOR4XL $PINS A=B[35] B=B[34] C=B[33] D=B[32] Y=n1474
XU684 AOI2BB1XL $PINS A0N=n1489 A1N=A[1] B0=B[0] Y=n1457
XU685 OAI21XL $PINS A0=A[6] A1=n1487 B0=n1460 Y=n1452
XU686 AOI22XL $PINS A0=A[1] A1=n1489 B0=n1457 B1=FE_OFN5853_FE_DBTN21_N1711
+ Y=n1450
.ENDS

.SUBCKT CONV_DW_cmp_1 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] TC GE_LT GE_GT_EQ
+ GE_LT_GT_LE EQ_NE p1 p2 FE_OFN54_register_6__9
XFE_RC_801_0 OAI21XL $PINS A0=n1448 A1=n1469 B0=n1468 Y=n1461
XFE_RC_789_0 OAI21XL $PINS A0=n1452 A1=n1459 B0=n1458 Y=n1443
XFE_RC_782_0 AOI21X1 $PINS A0=n1464 A1=n1465 B0=n1463 Y=n1462
XU666 AND2X2 $PINS A=B[3] B=A[3] Y=n1456
XU620 AOI32X1 $PINS A0=A[6] A1=n1491 A2=n1460 B0=n1490 B1=A[7] Y=n1458
XU621 AOI32X1 $PINS A0=A[10] A1=n1494 A2=n1470 B0=n1499 B1=A[11] Y=n1468
XU623 AOI32X1 $PINS A0=n1455 A1=n1492 A2=A[4] B0=A[5] B1=n1495 Y=n1459
XU624 AOI32XL $PINS A0=A[18] A1=n1496 A2=n1479 B0=n1498 B1=A[19] Y=n1477
XU625 OAI32X1 $PINS A0=n1442 A1=n1443 A2=n1444 B0=n1445 B1=n1442 Y=n1441
XU627 NOR3BX1 $PINS AN=n1446 B=n1447 C=n1448 Y=n1445
XU628 OAI2BB1X1 $PINS A0N=n1461 A1N=n1446 B0=n1462 Y=n1442
XU629 OAI32X1 $PINS A0=A[2] A1=B[2] A2=n1456 B0=B[3] B1=A[3] Y=n1454
XU630 OAI33X1 $PINS A0=n1483 A1=n1437 A2=n1438 B0=n1439 B1=n1440 B2=n1441
+ Y=GE_LT_GT_LE
XU631 OAI21XL $PINS A0=A[16] A1=n1501 B0=n1471 Y=n1440
XU632 INVX1 $PINS A=n1414 Y=n1483
XU633 OR3XL $PINS A=n1438 B=n1437 C=n1472 Y=n1439
XU635 AOI211X1 $PINS A0=n1450 A1=n1480 B0=n1451 C0=n1452 Y=n1444
XU636 AOI22XL $PINS A0=A[1] A1=n1493 B0=n1457 B1=A[0] Y=n1450
XU637 INVX1 $PINS A=n1454 Y=n1480
XU638 OAI221XL $PINS A0=A[4] A1=n1492 B0=n1453 B1=n1454 C0=n1455 Y=n1451
XU639 NAND2X1 $PINS A=n1473 B=n1474 Y=n1438
XU640 NOR4X1 $PINS A=B[31] B=B[30] C=B[29] D=B[28] Y=n1473
XU641 AOI211X1 $PINS A0=A[12] A1=B[12] B0=n1466 C0=n1485 Y=n1446
XU642 INVX1 $PINS A=n1465 Y=n1485
XU644 OAI21XL $PINS A0=A[10] A1=n1494 B0=n1470 Y=n1448
XU645 NOR2BXL $PINS AN=B[15] B=A[15] Y=n1467
XU647 NOR2BXL $PINS AN=B[13] B=A[13] Y=n1466
XU648 OAI21XL $PINS A0=A[6] A1=n1491 B0=n1460 Y=n1452
XU649 AOI21X1 $PINS A0=A[14] A1=B[14] B0=n1467 Y=n1465
XU651 OAI32X1 $PINS A0=A[12] A1=B[12] A2=n1466 B0=B[13] B1=p1 Y=n1464
XU652 OAI32X1 $PINS A0=A[14] A1=B[14] A2=n1467 B0=B[15] B1=p2 Y=n1463
XU656 AOI32XL $PINS A0=n1449 A1=n1489 A2=A[8] B0=FE_OFN54_register_6__9
+ B1=n1500 Y=n1469
XU657 INVX1 $PINS A=B[9] Y=n1500
XU658 NAND2BXL $PINS AN=FE_OFN54_register_6__9 B=B[9] Y=n1449
XU659 AOI21X1 $PINS A0=B[2] A1=A[2] B0=n1456 Y=n1453
XU660 NAND2X1 $PINS A=n1475 B=n1476 Y=n1437
XU661 NOR4X1 $PINS A=B[23] B=B[22] C=B[21] D=B[20] Y=n1475
XU662 NOR4X1 $PINS A=B[27] B=B[26] C=B[25] D=B[24] Y=n1476
XU663 NAND2BXL $PINS AN=A[5] B=B[5] Y=n1455
XU664 INVX1 $PINS A=B[7] Y=n1490
XU665 OR2XL $PINS A=A[7] B=n1490 Y=n1460
XU667 INVX1 $PINS A=B[11] Y=n1499
XU668 OR2XL $PINS A=A[11] B=n1499 Y=n1470
XU669 INVX1 $PINS A=B[5] Y=n1495
XU670 OAI21XL $PINS A0=A[8] A1=n1489 B0=n1449 Y=n1447
XU671 OAI21XL $PINS A0=A[18] A1=n1496 B0=n1479 Y=n1472
XU672 INVX1 $PINS A=B[16] Y=n1501
XU673 INVX1 $PINS A=B[18] Y=n1496
XU674 INVX1 $PINS A=B[17] Y=n1497
XU675 INVX1 $PINS A=B[19] Y=n1498
XU676 OAI21XL $PINS A0=n1478 A1=n1472 B0=n1477 Y=n1414
XU677 AOI32XL $PINS A0=A[16] A1=n1501 A2=n1471 B0=n1497 B1=A[17] Y=n1478
XU678 INVX1 $PINS A=B[8] Y=n1489
XU679 INVX1 $PINS A=B[6] Y=n1491
XU680 INVX1 $PINS A=B[10] Y=n1494
XU681 INVX1 $PINS A=B[1] Y=n1493
XU682 AOI2BB1XL $PINS A0N=n1493 A1N=A[1] B0=B[0] Y=n1457
XU683 OR2XL $PINS A=A[17] B=n1497 Y=n1471
XU684 OR2XL $PINS A=A[19] B=n1498 Y=n1479
XU685 INVX1 $PINS A=B[4] Y=n1492
XU686 NOR4XL $PINS A=B[35] B=B[34] C=B[33] D=B[32] Y=n1474
.ENDS

.SUBCKT CONV_DW_cmp_2 A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE n4937 p1
+ FE_OFN58_register_5__4 FE_DBTN100_register_4_14 FE_OFN332_register_5__4
+ _register_4_14 _register_4_8 _register_5_3 _register_4_11 _register_4_10
+ _register_4_16 p_2 FE_OCPN103_register_4__7
XFE_RC_800_0 INVX1 $PINS A=n141 Y=FE_RN_407_0
XFE_RC_799_0 OAI2BB1X1 $PINS A0N=B[19] A1N=A[19] B0=FE_RN_407_0 Y=n178
XFE_RC_794_0 INVX1 $PINS A=n152 Y=FE_RN_404_0
XFE_RC_793_0 OAI2BB1X1 $PINS A0N=_register_4_10 A1N=A[10] B0=FE_RN_404_0 Y=n180
XFE_RC_783_0 AOI21X1 $PINS A0=A[5] A1=B[5] B0=n163 Y=n155
XFE_RC_780_0 OAI21XL $PINS A0=p_2 A1=_register_5_3 B0=n160 Y=n159
XU61 OAI222XL $PINS A0=A[9] A1=n166 B0=n166 B1=B[9] C0=A[9] C1=B[9] Y=n146
XU62 OAI222XL $PINS A0=A[13] A1=n173 B0=B[13] B1=n173 C0=A[13] C1=B[13] Y=n172
XU64 OAI221XL $PINS A0=B[3] A1=p1 B0=n157 B1=n158 C0=n159 Y=n156
XU65 OAI221XL $PINS A0=_register_4_10 A1=n146 B0=_register_4_10 B1=A[10]
+ C0=n147 Y=n145
XU66 NOR2BXL $PINS AN=_register_4_11 B=A[11] Y=n170
XU67 OAI211X1 $PINS A0=A[15] A1=B[15] B0=n144 C0=n145 Y=n139
XU68 OAI222XL $PINS A0=A[15] A1=n171 B0=B[15] B1=n171 C0=A[15] C1=B[15] Y=n138
XU69 OAI222XL $PINS A0=_register_4_14 A1=A[14] B0=_register_4_14 B1=n172
+ C0=A[14] C1=n172 Y=n171
XU70 OAI222XL $PINS A0=A[12] A1=n174 B0=B[12] B1=n174 C0=B[12] C1=A[12] Y=n173
XU72 NOR2BXL $PINS AN=A[2] B=B[2] Y=n160
XU73 NOR2BXL $PINS AN=_register_4_16 B=A[16] Y=n143
XU74 OAI221XL $PINS A0=B[19] A1=n135 B0=B[19] B1=A[19] C0=n136 Y=GE_LT_GT_LE
XU75 AOI2BB1X1 $PINS A0N=A[19] A1N=n135 B0=n137 Y=n136
XU76 OAI222XL $PINS A0=A[18] A1=n175 B0=n175 B1=B[18] C0=A[18] C1=B[18] Y=n135
XU77 AOI21X1 $PINS A0=n138 A1=n139 B0=n178 Y=n137
XU78 OAI22XL $PINS A0=n168 A1=A[14] B0=_register_4_14 B1=n168 Y=n144
XU79 OAI21XL $PINS A0=A[13] A1=B[13] B0=n169 Y=n168
XU80 OAI211XL $PINS A0=A[6] A1=B[6] B0=n155 C0=n156 Y=n150
XU83 AOI2BB1X1 $PINS A0N=A[10] A1N=n146 B0=n148 Y=n147
XU84 AOI21X1 $PINS A0=n149 A1=n150 B0=n180 Y=n148
XU86 OAI222XL $PINS A0=A[6] A1=n164 B0=B[6] B1=n164 C0=A[6] C1=B[6] Y=n149
XU87 OAI222XL $PINS A0=n176 A1=A[17] B0=B[17] B1=n176 C0=B[17] C1=A[17] Y=n175
XU88 NAND2BXL $PINS AN=_register_4_16 B=A[16] Y=n176
XU89 OAI222XL $PINS A0=n167 A1=A[8] B0=_register_4_8 B1=n167 C0=_register_4_8
+ C1=A[8] Y=n166
XU90 NAND2BXL $PINS AN=FE_OCPN103_register_4__7 B=A[7] Y=n167
XU91 OAI222XL $PINS A0=A[5] A1=n165 B0=B[5] B1=n165 C0=B[5] C1=A[5] Y=n164
XU96 OAI21XL $PINS A0=A[9] A1=B[9] B0=n153 Y=n152
XU97 OAI22XL $PINS A0=n154 A1=A[8] B0=_register_4_8 B1=n154 Y=n153
XU98 NOR2BXL $PINS AN=B[7] B=A[7] Y=n154
XU101 OAI21XL $PINS A0=A[18] A1=B[18] B0=n142 Y=n141
XU102 OAI22XL $PINS A0=n143 A1=A[17] B0=B[17] B1=n143 Y=n142
XU103 NAND2BXL $PINS AN=_register_4_11 B=A[11] Y=n174
XU104 AOI2BB1X1 $PINS A0N=A[1] A1N=B[1] B0=n161 Y=n158
XU105 AOI22XL $PINS A0=B[1] A1=A[1] B0=B[0] B1=A[0] Y=n161
XU110 OAI22XL $PINS A0=n170 A1=A[12] B0=B[12] B1=n170 Y=n169
XU116 AOI22XL $PINS A0=n162 A1=p_2 B0=n162 B1=_register_5_3 Y=n157
XU117 NAND2BXL $PINS AN=A[2] B=B[2] Y=n162
XU118 NAND2BXL $PINS AN=B[4] B=FE_OFN58_register_5__4 Y=n165
XU119 NOR2BXL $PINS AN=B[4] B=FE_OFN58_register_5__4 Y=n163
.ENDS

.SUBCKT CONV_DW_cmp_3 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] TC GE_LT GE_GT_EQ
+ GE_LT_GT_LE EQ_NE n5107 p1 FE_OFN101_CMF0_16 FE_OFN98_CMF0_18
+ FE_OFN96_CMF0_19 FE_OFN123_CMF0_1 FE_OFN119_CMF0_4 FE_OFN111_CMF0_8
+ FE_OFN115_CMF0_6 FE_OFN117_CMF0_5 FE_OFN113_CMF0_7 FE_OFN108_CMF0_10
+ _register_3_16 N611 _register_3_18
XFE_RC_791_0 OAI21XL $PINS A0=n1448 A1=n1469 B0=n1468 Y=n1461
XFE_RC_790_0 OAI21XL $PINS A0=n1452 A1=n1459 B0=n1458 Y=n1443
XFE_RC_784_0 AOI21X1 $PINS A0=n1464 A1=n1465 B0=n1463 Y=n1462
XU658 AND2X2 $PINS A=B[3] B=A[3] Y=n1456
XU620 AOI32X1 $PINS A0=A[10] A1=FE_OFN108_CMF0_10 A2=n1470 B0=n1496 B1=A[11]
+ Y=n1468
XU621 AOI32XL $PINS A0=A[6] A1=FE_OFN115_CMF0_6 A2=n1460 B0=FE_OFN113_CMF0_7
+ B1=N611 Y=n1458
XU622 AOI32XL $PINS A0=n1449 A1=FE_OFN111_CMF0_8 A2=A[8] B0=A[9] B1=n1498
+ Y=n1469
XU623 OAI33X1 $PINS A0=n1480 A1=n1437 A2=n1438 B0=n1439 B1=n1440 B2=n1441
+ Y=GE_LT_GT_LE
XU624 OAI21XL $PINS A0=_register_3_16 A1=FE_OFN101_CMF0_16 B0=n1471 Y=n1440
XU625 INVX1 $PINS A=n1414 Y=n1480
XU626 OAI32X1 $PINS A0=n1442 A1=n1443 A2=n1444 B0=n1445 B1=n1442 Y=n1441
XU627 OR3XL $PINS A=n1438 B=n1437 C=n1472 Y=n1439
XU628 OAI21XL $PINS A0=A[10] A1=FE_OFN108_CMF0_10 B0=n1470 Y=n1448
XU630 OAI32X1 $PINS A0=A[14] A1=B[14] A2=n1467 B0=B[15] B1=p1 Y=n1463
XU632 OAI32X1 $PINS A0=A[2] A1=B[2] A2=n1456 B0=B[3] B1=A[3] Y=n1454
XU633 AOI211X1 $PINS A0=A[12] A1=B[12] B0=n1466 C0=n1482 Y=n1446
XU634 INVX1 $PINS A=n1465 Y=n1482
XU635 AOI211X1 $PINS A0=n1450 A1=n1484 B0=n1451 C0=n1452 Y=n1444
XU636 INVX1 $PINS A=n1454 Y=n1484
XU637 OAI221XL $PINS A0=A[4] A1=FE_OFN119_CMF0_4 B0=n1453 B1=n1454 C0=n1455
+ Y=n1451
XU638 NOR2BXL $PINS AN=B[15] B=A[15] Y=n1467
XU640 AOI21X1 $PINS A0=A[14] A1=B[14] B0=n1467 Y=n1465
XU642 AOI32XL $PINS A0=n1455 A1=FE_OFN119_CMF0_4 A2=A[4] B0=A[5]
+ B1=FE_OFN117_CMF0_5 Y=n1459
XU645 NOR3BX1 $PINS AN=n1446 B=n1447 C=n1448 Y=n1445
XU646 OAI21XL $PINS A0=A[8] A1=FE_OFN111_CMF0_8 B0=n1449 Y=n1447
XU647 OAI2BB1X1 $PINS A0N=n1461 A1N=n1446 B0=n1462 Y=n1442
XU650 OAI32X1 $PINS A0=A[12] A1=B[12] A2=n1466 B0=B[13] B1=n5107 Y=n1464
XU651 NAND2X1 $PINS A=n1473 B=n1474 Y=n1438
XU652 NOR4X1 $PINS A=B[31] B=B[30] C=B[29] D=B[28] Y=n1473
XU653 NOR4X1 $PINS A=B[35] B=B[34] C=B[33] D=B[32] Y=n1474
XU654 AOI21X1 $PINS A0=B[2] A1=A[2] B0=n1456 Y=n1453
XU655 INVX1 $PINS A=B[11] Y=n1496
XU657 OR2XL $PINS A=A[11] B=n1496 Y=n1470
XU661 OR2XL $PINS A=N611 B=FE_OFN113_CMF0_7 Y=n1460
XU662 INVX1 $PINS A=B[9] Y=n1498
XU663 OAI21XL $PINS A0=_register_3_18 A1=FE_OFN98_CMF0_18 B0=n1479 Y=n1472
XU666 NOR2BXL $PINS AN=B[13] B=A[13] Y=n1466
XU668 INVX1 $PINS A=B[17] Y=n1494
XU670 OAI21XL $PINS A0=n1478 A1=n1472 B0=n1477 Y=n1414
XU671 AOI32XL $PINS A0=_register_3_16 A1=FE_OFN101_CMF0_16 A2=n1471 B0=n1494
+ B1=A[17] Y=n1478
XU672 AOI32XL $PINS A0=_register_3_18 A1=FE_OFN98_CMF0_18 A2=n1479
+ B0=FE_OFN96_CMF0_19 B1=A[19] Y=n1477
XU676 NAND2X1 $PINS A=n1475 B=n1476 Y=n1437
XU677 NOR4X1 $PINS A=B[23] B=B[22] C=B[21] D=B[20] Y=n1475
XU678 NOR4X1 $PINS A=B[27] B=B[26] C=B[25] D=B[24] Y=n1476
XU679 NAND2BXL $PINS AN=A[5] B=B[5] Y=n1455
XU680 OR2XL $PINS A=A[19] B=FE_OFN96_CMF0_19 Y=n1479
XU681 OR2XL $PINS A=A[17] B=n1494 Y=n1471
XU683 NAND2BXL $PINS AN=A[9] B=B[9] Y=n1449
XU684 OAI21XL $PINS A0=A[6] A1=FE_OFN115_CMF0_6 B0=n1460 Y=n1452
XU685 AOI2BB1XL $PINS A0N=FE_OFN123_CMF0_1 A1N=A[1] B0=B[0] Y=n1457
XU686 AOI22XL $PINS A0=A[1] A1=FE_OFN123_CMF0_1 B0=n1457 B1=A[0] Y=n1450
.ENDS

.SUBCKT CONV_DW_cmp_4 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] TC GE_LT GE_GT_EQ
+ GE_LT_GT_LE EQ_NE n5475 n5214 _register_2_10 _register_2_11 p1 p2
+ FE_OFN101_CMF0_16 FE_OFN98_CMF0_18 FE_OFN96_CMF0_19 FE_OFN123_CMF0_1
+ FE_OFN119_CMF0_4 FE_OFN111_CMF0_8 FE_OFN115_CMF0_6 FE_OFN117_CMF0_5
+ FE_OFN113_CMF0_7 FE_OFN108_CMF0_10 FE_OFN66_register_2__8
XFE_RC_792_0 OAI21XL $PINS A0=n1448 A1=n1469 B0=n1468 Y=n1461
XFE_RC_786_0 OAI21XL $PINS A0=n1452 A1=n1459 B0=n1458 Y=n1443
XFE_RC_785_0 AOI21X1 $PINS A0=n1464 A1=n1465 B0=n1463 Y=n1462
XFE_OFC1548_register_2__8 INVXL $PINS A=A[8] Y=FE_OFN5752_register_2__8
XU664 AND2X2 $PINS A=B[3] B=n5475 Y=n1456
XU621 AOI32XL $PINS A0=A[16] A1=FE_OFN101_CMF0_16 A2=n1471 B0=n1492 B1=A[17]
+ Y=n1478
XU622 AOI32X1 $PINS A0=A[18] A1=FE_OFN98_CMF0_18 A2=n1479 B0=FE_OFN96_CMF0_19
+ B1=A[19] Y=n1477
XU623 NAND2BXL $PINS AN=A[9] B=B[9] Y=n1449
XU624 OAI32X1 $PINS A0=n1442 A1=n1443 A2=n1444 B0=n1445 B1=n1442 Y=n1441
XU626 NOR3BX1 $PINS AN=n1446 B=n1447 C=n1448 Y=n1445
XU627 AOI211X1 $PINS A0=n1450 A1=n1482 B0=n1451 C0=n1452 Y=n1444
XU628 INVX1 $PINS A=n1454 Y=n1482
XU629 OAI33X1 $PINS A0=n1480 A1=n1437 A2=n1438 B0=n1439 B1=n1440 B2=n1441
+ Y=GE_LT_GT_LE
XU630 OR2XL $PINS A=A[7] B=FE_OFN113_CMF0_7 Y=n1460
XU631 OR3XL $PINS A=n1438 B=n1437 C=n1472 Y=n1439
XU632 OAI21XL $PINS A0=_register_2_10 A1=FE_OFN108_CMF0_10 B0=n1470 Y=n1448
XU633 OAI21XL $PINS A0=A[16] A1=FE_OFN101_CMF0_16 B0=n1471 Y=n1440
XU634 AOI32XL $PINS A0=A[6] A1=FE_OFN115_CMF0_6 A2=n1460 B0=FE_OFN113_CMF0_7
+ B1=A[7] Y=n1458
XU635 OAI32X1 $PINS A0=A[14] A1=B[14] A2=n1467 B0=B[15] B1=p2 Y=n1463
XU638 OAI32X1 $PINS A0=n5214 A1=B[2] A2=n1456 B0=B[3] B1=n5475 Y=n1454
XU641 AOI211X1 $PINS A0=A[12] A1=B[12] B0=n1466 C0=n1496 Y=n1446
XU642 INVX1 $PINS A=n1465 Y=n1496
XU643 AOI21X1 $PINS A0=A[14] A1=B[14] B0=n1467 Y=n1465
XU644 NAND2X1 $PINS A=n1473 B=n1474 Y=n1438
XU645 NOR4X1 $PINS A=B[31] B=B[30] C=B[29] D=B[28] Y=n1473
XU646 NOR4X1 $PINS A=B[35] B=B[34] C=B[33] D=B[32] Y=n1474
XU647 AOI32XL $PINS A0=_register_2_10 A1=FE_OFN108_CMF0_10 A2=n1470 B0=n1494
+ B1=_register_2_11 Y=n1468
XU648 OAI2BB1X1 $PINS A0N=n1461 A1N=n1446 B0=n1462 Y=n1442
XU651 AOI32XL $PINS A0=n1449 A1=FE_OFN111_CMF0_8 A2=FE_OFN66_register_2__8
+ B0=A[9] B1=n1497 Y=n1469
XU654 INVX1 $PINS A=B[11] Y=n1494
XU655 AOI32XL $PINS A0=n1455 A1=FE_OFN119_CMF0_4 A2=A[4] B0=A[5]
+ B1=FE_OFN117_CMF0_5 Y=n1459
XU657 OAI221XL $PINS A0=A[4] A1=FE_OFN119_CMF0_4 B0=n1453 B1=n1454 C0=n1455
+ Y=n1451
XU658 AOI21X1 $PINS A0=B[2] A1=n5214 B0=n1456 Y=n1453
XU659 OAI32X1 $PINS A0=A[12] A1=B[12] A2=n1466 B0=B[13] B1=p1 Y=n1464
XU661 OAI21XL $PINS A0=A[18] A1=FE_OFN98_CMF0_18 B0=n1479 Y=n1472
XU666 NOR2BXL $PINS AN=B[13] B=A[13] Y=n1466
XU667 INVX1 $PINS A=B[17] Y=n1492
XU670 NAND2X1 $PINS A=n1475 B=n1476 Y=n1437
XU671 NOR4X1 $PINS A=B[23] B=B[22] C=B[21] D=B[20] Y=n1475
XU672 NOR4X1 $PINS A=B[27] B=B[26] C=B[25] D=B[24] Y=n1476
XU673 OR2XL $PINS A=A[17] B=n1492 Y=n1471
XU676 INVX1 $PINS A=B[9] Y=n1497
XU677 INVX1 $PINS A=n1414 Y=n1480
XU678 OAI21XL $PINS A0=n1478 A1=n1472 B0=n1477 Y=n1414
XU679 NAND2BXL $PINS AN=A[5] B=B[5] Y=n1455
XU680 AOI22XL $PINS A0=A[1] A1=FE_OFN123_CMF0_1 B0=n1457 B1=A[0] Y=n1450
XU681 AOI2BB1XL $PINS A0N=FE_OFN123_CMF0_1 A1N=A[1] B0=B[0] Y=n1457
XU682 OR2XL $PINS A=A[19] B=FE_OFN96_CMF0_19 Y=n1479
XU683 OAI21XL $PINS A0=A[6] A1=FE_OFN115_CMF0_6 B0=n1460 Y=n1452
XU684 OR2XL $PINS A=_register_2_11 B=n1494 Y=n1470
XU685 NOR2BXL $PINS AN=B[15] B=A[15] Y=n1467
XU686 OAI21XL $PINS A0=FE_OFN5752_register_2__8 A1=FE_OFN111_CMF0_8 B0=n1449
+ Y=n1447
.ENDS

.SUBCKT CONV_DW_cmp_5 A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE n5504 _register_1_11 n4988
+ _register_0_17 p1 p2 FE_OFN93_register_1__6 FE_OFN5901_register_0__12
XFE_RC_798_0 INVX1 $PINS A=n141 Y=FE_RN_406_0
XFE_RC_797_0 OAI2BB1X1 $PINS A0N=B[19] A1N=n4988 B0=FE_RN_406_0 Y=n177
XFE_RC_796_0 INVX1 $PINS A=n152 Y=FE_RN_405_0
XFE_RC_795_0 OAI2BB1X1 $PINS A0N=B[10] A1N=A[10] B0=FE_RN_405_0 Y=n180
XFE_RC_781_0 OAI21XL $PINS A0=p2 A1=A[3] B0=n160 Y=n159
XFE_RC_779_0 AOI21X1 $PINS A0=A[5] A1=B[5] B0=n163 Y=n155
XFE_RC_778_0 AOI21X1 $PINS A0=A[17] A1=_register_0_17 B0=n143 Y=n142
XFE_RC_777_0 AOI21X1 $PINS A0=A[8] A1=B[8] B0=n154 Y=n153
XU61 OAI222XL $PINS A0=B[14] A1=A[14] B0=B[14] B1=n172 C0=A[14] C1=n172 Y=n171
XU62 OAI222XL $PINS A0=A[12] A1=n174 B0=FE_OFN5901_register_0__12 B1=n174
+ C0=FE_OFN5901_register_0__12 C1=A[12] Y=n173
XU68 NOR2BX1 $PINS AN=B[4] B=A[4] Y=n163
XU72 OAI221XL $PINS A0=B[3] A1=p1 B0=n157 B1=n158 C0=n159 Y=n156
XU73 OAI222XL $PINS A0=A[9] A1=n166 B0=n166 B1=B[9] C0=A[9] C1=B[9] Y=n146
XU75 OAI222XL $PINS A0=A[13] A1=n173 B0=B[13] B1=n173 C0=A[13] C1=B[13] Y=n172
XU76 NOR2BXL $PINS AN=A[2] B=B[2] Y=n160
XU77 NOR2BXL $PINS AN=B[7] B=A[7] Y=n154
XU78 OAI222XL $PINS A0=A[15] A1=n171 B0=n186 B1=n171 C0=A[15] C1=n186 Y=n138
XU79 NAND2BXL $PINS AN=B[11] B=_register_1_11 Y=n174
XU80 OAI221XL $PINS A0=B[19] A1=n135 B0=B[19] B1=n4988 C0=n136 Y=GE_LT_GT_LE
XU81 AOI2BB1X1 $PINS A0N=n4988 A1N=n135 B0=n137 Y=n136
XU82 OAI222XL $PINS A0=A[18] A1=n175 B0=n175 B1=B[18] C0=A[18] C1=B[18] Y=n135
XU83 AOI21X1 $PINS A0=n138 A1=n139 B0=n177 Y=n137
XU84 OAI222XL $PINS A0=n167 A1=A[8] B0=B[8] B1=n167 C0=B[8] C1=A[8] Y=n166
XU85 NAND2BXL $PINS AN=B[7] B=A[7] Y=n167
XU86 OAI222XL $PINS A0=n176 A1=A[17] B0=_register_0_17 B1=n176
+ C0=_register_0_17 C1=A[17] Y=n175
XU87 NAND2BXL $PINS AN=B[16] B=A[16] Y=n176
XU88 OAI211XL $PINS A0=A[6] A1=B[6] B0=n155 C0=n156 Y=n150
XU89 OAI211XL $PINS A0=A[15] A1=n186 B0=n144 C0=n145 Y=n139
XU90 OAI22XL $PINS A0=n168 A1=A[14] B0=B[14] B1=n168 Y=n144
XU91 OAI221XL $PINS A0=B[10] A1=n146 B0=B[10] B1=A[10] C0=n147 Y=n145
XU93 NOR2BXL $PINS AN=B[16] B=A[16] Y=n143
XU94 OAI22XL $PINS A0=n170 A1=A[12] B0=FE_OFN5901_register_0__12 B1=n170 Y=n169
XU95 NOR2BXL $PINS AN=B[11] B=_register_1_11 Y=n170
XU97 OAI21XL $PINS A0=A[9] A1=B[9] B0=n153 Y=n152
XU101 OAI222XL $PINS A0=A[5] A1=n165 B0=B[5] B1=n165 C0=B[5] C1=A[5] Y=n164
XU102 AOI2BB1X1 $PINS A0N=A[10] A1N=n146 B0=n148 Y=n147
XU103 AOI21X1 $PINS A0=n149 A1=n150 B0=n180 Y=n148
XU105 OAI222XL $PINS A0=FE_OFN93_register_1__6 A1=n164 B0=B[6] B1=n164
+ C0=FE_OFN93_register_1__6 C1=B[6] Y=n149
XU109 INVXL $PINS A=B[15] Y=n186
XU111 NAND2BXL $PINS AN=A[2] B=B[2] Y=n162
XU112 AOI2BB1XL $PINS A0N=n5504 A1N=B[1] B0=n161 Y=n158
XU113 NAND2BXL $PINS AN=B[4] B=A[4] Y=n165
XU114 OAI21XL $PINS A0=A[18] A1=B[18] B0=n142 Y=n141
XU117 AOI22XL $PINS A0=n162 A1=p2 B0=n162 B1=A[3] Y=n157
XU118 OAI21XL $PINS A0=A[13] A1=B[13] B0=n169 Y=n168
XU119 AOI22XL $PINS A0=B[1] A1=n5504 B0=B[0] B1=A[0] Y=n161
.ENDS

.SUBCKT CONV_DW01_inc_1_DW01_inc_2 A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5]
+ A[4] A[3] A[2] A[1] A[0] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6]
+ SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0]
XU1_1_5 ADDHXL $PINS A=A[5] B=carry[5] S=SUM[5] CO=carry[6]
XU1_1_4 ADDHXL $PINS A=A[4] B=carry[4] S=SUM[4] CO=carry[5]
XU1_1_3 ADDHXL $PINS A=A[3] B=carry[3] S=SUM[3] CO=carry[4]
XU1_1_2 ADDHXL $PINS A=A[2] B=carry[2] S=SUM[2] CO=carry[3]
XU1_1_10 ADDHXL $PINS A=A[10] B=carry[10] S=SUM[10] CO=carry[11]
XU1_1_8 ADDHXL $PINS A=A[8] B=carry[8] S=SUM[8] CO=carry[9]
XU1_1_9 ADDHXL $PINS A=A[9] B=carry[9] S=SUM[9] CO=carry[10]
XU1_1_7 ADDHXL $PINS A=A[7] B=carry[7] S=SUM[7] CO=carry[8]
XU1_1_6 ADDHXL $PINS A=A[6] B=carry[6] S=SUM[6] CO=carry[7]
XU1_1_1 ADDHXL $PINS A=A[1] B=A[0] S=SUM[1] CO=carry[2]
XU1_1_11 ADDHXL $PINS A=A[11] B=carry[11] S=SUM[11] CO=carry[12]
XU1 INVXL $PINS A=A[0] Y=SUM[0]
XU2 XOR2XL $PINS A=carry[12] B=A[12] Y=SUM[12]
.ENDS

.SUBCKT CONV_DW01_inc_2_DW01_inc_3 A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5]
+ A[4] A[3] A[2] A[1] A[0] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6]
+ SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] p1
*.CONNECT SUM[0] p1
XU1_1_10 ADDHXL $PINS A=A[10] B=carry[10] S=SUM[10] CO=carry[11]
XU1_1_2 ADDHXL $PINS A=A[2] B=carry[2] S=SUM[2] CO=carry[3]
XU1_1_4 ADDHXL $PINS A=A[4] B=carry[4] S=SUM[4] CO=carry[5]
XU1_1_5 ADDHXL $PINS A=A[5] B=carry[5] S=SUM[5] CO=carry[6]
XU1_1_8 ADDHXL $PINS A=A[8] B=carry[8] S=SUM[8] CO=carry[9]
XU1_1_3 ADDHXL $PINS A=A[3] B=carry[3] S=SUM[3] CO=carry[4]
XU1_1_9 ADDHXL $PINS A=A[9] B=carry[9] S=SUM[9] CO=carry[10]
XU1_1_6 ADDHXL $PINS A=A[6] B=carry[6] S=SUM[6] CO=carry[7]
XU1_1_1 ADDHXL $PINS A=A[1] B=A[0] S=SUM[1] CO=carry[2]
XU1_1_11 ADDHXL $PINS A=A[11] B=carry[11] S=SUM[11] CO=carry[12]
XU1_1_7 ADDHXL $PINS A=A[7] B=carry[7] S=SUM[7] CO=carry[8]
XU2 XOR2X1 $PINS A=carry[12] B=A[12] Y=SUM[12]
.ENDS

.SUBCKT CONV_DW01_inc_3_DW01_inc_4 A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] SUM[19]
+ SUM[18] SUM[17] SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10]
+ SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0]
XU1_1_16 ADDHXL $PINS A=A[16] B=carry[16] S=SUM[16] CO=carry[17]
XU1_1_15 ADDHXL $PINS A=A[15] B=carry[15] S=SUM[15] CO=carry[16]
XU1_1_10 ADDHXL $PINS A=A[10] B=carry[10] S=SUM[10] CO=carry[11]
XU1_1_3 ADDHXL $PINS A=A[3] B=carry[3] S=SUM[3] CO=carry[4]
XU1_1_2 ADDHXL $PINS A=A[2] B=carry[2] S=SUM[2] CO=carry[3]
XU1_1_7 ADDHXL $PINS A=A[7] B=carry[7] S=SUM[7] CO=carry[8]
XU1_1_9 ADDHXL $PINS A=A[9] B=carry[9] S=SUM[9] CO=carry[10]
XU1_1_5 ADDHXL $PINS A=A[5] B=carry[5] S=SUM[5] CO=carry[6]
XU1_1_6 ADDHXL $PINS A=A[6] B=carry[6] S=SUM[6] CO=carry[7]
XU1_1_8 ADDHXL $PINS A=A[8] B=carry[8] S=SUM[8] CO=carry[9]
XU1_1_4 ADDHXL $PINS A=A[4] B=carry[4] S=SUM[4] CO=carry[5]
XU1_1_1 ADDHXL $PINS A=A[1] B=A[0] S=SUM[1] CO=carry[2]
XU1_1_17 ADDHXL $PINS A=A[17] B=carry[17] S=SUM[17] CO=carry[18]
XU1_1_11 ADDHXL $PINS A=A[11] B=carry[11] S=SUM[11] CO=carry[12]
XU1_1_12 ADDHXL $PINS A=A[12] B=carry[12] S=SUM[12] CO=carry[13]
XU1_1_13 ADDHXL $PINS A=A[13] B=carry[13] S=SUM[13] CO=carry[14]
XU1_1_14 ADDHXL $PINS A=A[14] B=carry[14] S=SUM[14] CO=carry[15]
XU1_1_18 ADDHXL $PINS A=A[18] B=carry[18] S=SUM[18] CO=carry[19]
XU1 XOR2XL $PINS A=carry[19] B=A[19] Y=SUM[19]
XU2 INVX1 $PINS A=A[0] Y=SUM[0]
.ENDS

.SUBCKT CONV_DW01_inc_4_DW01_inc_5 A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] SUM[19]
+ SUM[18] SUM[17] SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10]
+ SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0]
XU1_1_11 ADDHXL $PINS A=A[11] B=carry[11] S=SUM[11] CO=carry[12]
XU1_1_10 ADDHXL $PINS A=A[10] B=carry[10] S=SUM[10] CO=carry[11]
XU1_1_12 ADDHXL $PINS A=A[12] B=carry[12] S=SUM[12] CO=carry[13]
XU1_1_3 ADDHXL $PINS A=A[3] B=carry[3] S=SUM[3] CO=carry[4]
XU1_1_2 ADDHXL $PINS A=A[2] B=carry[2] S=SUM[2] CO=carry[3]
XU1_1_7 ADDHXL $PINS A=A[7] B=carry[7] S=SUM[7] CO=carry[8]
XU1_1_9 ADDHXL $PINS A=A[9] B=carry[9] S=SUM[9] CO=carry[10]
XU1_1_5 ADDHXL $PINS A=A[5] B=carry[5] S=SUM[5] CO=carry[6]
XU1_1_8 ADDHXL $PINS A=A[8] B=carry[8] S=SUM[8] CO=carry[9]
XU1_1_6 ADDHXL $PINS A=A[6] B=carry[6] S=SUM[6] CO=carry[7]
XU1_1_4 ADDHXL $PINS A=A[4] B=carry[4] S=SUM[4] CO=carry[5]
XU1_1_1 ADDHXL $PINS A=A[1] B=A[0] S=SUM[1] CO=carry[2]
XU1_1_15 ADDHXL $PINS A=A[15] B=carry[15] S=SUM[15] CO=carry[16]
XU1_1_13 ADDHXL $PINS A=A[13] B=carry[13] S=SUM[13] CO=carry[14]
XU1_1_14 ADDHXL $PINS A=A[14] B=carry[14] S=SUM[14] CO=carry[15]
XU1_1_17 ADDHXL $PINS A=A[17] B=carry[17] S=SUM[17] CO=carry[18]
XU1_1_16 ADDHXL $PINS A=A[16] B=carry[16] S=SUM[16] CO=carry[17]
XU1_1_18 ADDHXL $PINS A=A[18] B=carry[18] S=SUM[18] CO=carry[19]
XU1 XOR2XL $PINS A=carry[19] B=A[19] Y=SUM[19]
.ENDS

.SUBCKT CONV_DW_mult_uns_20 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[14] b[13]
+ b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0]
+ product[34] product[33] product[32] product[31] product[30] product[29]
+ product[28] product[27] product[26] product[25] product[24] product[23]
+ product[22] product[21] product[20] product[19] product[18] product[17]
+ product[16] product[15] product[14] product[13] product[12] product[11]
+ product[10] product[9] product[8] product[7] product[6] product[5] product[4]
+ product[3] product[2] product[1] product[0] n5383 _register_2_10 p1 p2 p3 p4
+ p5 p6 p7 p8 p9 p10 p11 p12 p13 p14 p15 p16 p17 FE_OFN12_register_2__1
+ FE_OFN33_N567 FE_OFN44_n5215 p18 FE_OFN67_register_2__8
+ FE_OFN72_register_2__14 FE_OFN74_register_2__6 FE_OFN77_register_2__5
XFE_RC_654_0 AOI21X2 $PINS A0=n257 A1=n249 B0=n250 Y=n248
XFE_RC_638_0 OAI21XL $PINS A0=n181 A1=n185 B0=n182 Y=n180
XFE_OFC2137_n159 INVX2 $PINS A=n159 Y=n700
XFE_OFC2119_n277 INVX1 $PINS A=n277 Y=n702
XFE_OFC2112_n257 INVX1 $PINS A=n257 Y=n701
XFE_OFC2083_n230 CLKINVX3 $PINS A=n698 Y=FE_OFN6073_n230
XFE_OFC2082_n230 INVX4 $PINS A=n230 Y=n698
XFE_OFC2056_n248 INVX1 $PINS A=n697 Y=FE_OFN6063_n248
XFE_OFC2055_n248 INVX2 $PINS A=n248 Y=n697
XFE_OFC1766_register_2__18 INVX1 $PINS A=a[18] Y=FE_OFN5868_register_2__18
XFE_OFC1693_register_2__19 INVX1 $PINS A=p17 Y=FE_RN_1
XFE_OFC1611_register_2__6 INVX1 $PINS A=a[6] Y=FE_OFN5786_register_2__6
XFE_OFC855_n187 INVX8 $PINS A=n187 Y=n691
XFE_OFC635_n5215 INVX1 $PINS A=a[2] Y=FE_OFN408_n5215
XFE_OFC590_n208 INVX4 $PINS A=n208 Y=n690
XU135 XNOR2X2 $PINS A=n147 B=n13 Y=product[23]
XU166 AOI21X2 $PINS A0=n161 A1=n180 B0=n162 Y=n160
XU218 NOR2X2 $PINS A=n422 B=n431 Y=n195
XU226 NOR2X1 $PINS A=n432 B=n441 Y=n200
XU407 ADDFHX2 $PINS A=n445 B=n443 CI=n434 S=n432 CO=n431
XU121 XNOR2X4 $PINS A=n136 B=n12 Y=product[24]
XU238 AOI21X4 $PINS A0=n217 A1=n209 B0=n210 Y=n208
XU205 OAI21X4 $PINS A0=n208 A1=n188 B0=n189 Y=n187
XU516 NOR2X2 $PINS A=n442 B=n449 Y=n205
XU566 AND2X2 $PINS A=n143 B=n700 Y=n630
XU736 AND2X2 $PINS A=n645 B=n277 Y=product[1]
XU758 NOR2X2 $PINS A=n412 B=n421 Y=n192
XU807 AND2X2 $PINS A=n627 B=n109 Y=n646
XU482 XOR2X2 $PINS A=n444 B=n666 Y=n442
XU483 ADDFX2 $PINS A=a[16] B=a[12] CI=n5383 S=n370 CO=n369
XU484 OAI21XL $PINS A0=n84 A1=n710 B0=n83 Y=n73
XU485 NAND2X1 $PINS A=n695 B=n206 Y=n685
XU486 NAND2X1 $PINS A=n697 B=n29 Y=n651
XU487 NAND2X1 $PINS A=FE_OFN6063_n248 B=n650 Y=n652
XU488 NAND2X1 $PINS A=n651 B=n652 Y=product[7]
XU490 INVX1 $PINS A=n29 Y=n650
XU493 INVX1 $PINS A=n268 Y=n733
XU494 NAND2X1 $PINS A=a[3] B=FE_OFN44_n5215 Y=n268
XU495 NAND3X1 $PINS A=n669 B=n667 C=n668 Y=n441
XU496 NAND2X1 $PINS A=n453 B=n444 Y=n668
XU497 ADDFX2 $PINS A=a[2] B=a[9] CI=p4 S=n420 CO=n419
XU498 ADDFX2 $PINS A=p12 B=p4 CI=n440 S=n436 CO=n435
XU504 NOR2X1 $PINS A=n373 B=n366 Y=n152
XU505 ADDFX2 $PINS A=n377 B=n368 CI=n375 S=n366 CO=n365
XU506 ADDFX2 $PINS A=n385 B=n376 CI=n383 S=n374 CO=n373
XU507 XNOR2X1 $PINS A=n698 B=n26 Y=product[10]
XU508 NOR2X1 $PINS A=a[5] B=a[4] Y=n254
XU510 ADDHXL $PINS A=a[2] B=a[0] S=n484 CO=n483
XU512 NAND2X1 $PINS A=n614 B=n624 Y=n119
XU513 NAND2XL $PINS A=n714 B=n171 Y=n16
XU515 ADDFX2 $PINS A=a[8] B=p6 CI=n484 S=n482 CO=n481
XU517 ADDFX2 $PINS A=a[17] B=p11 CI=p9 S=n362 CO=n361
XU518 ADDFX2 $PINS A=a[18] B=n409 CI=n407 S=n396 CO=n395
XU519 ADDFHX1 $PINS A=n426 B=n433 CI=n424 S=n422 CO=n421
XU520 INVX1 $PINS A=n205 Y=n695
XU521 NAND2X2 $PINS A=n442 B=n449 Y=n206
XU522 INVX1 $PINS A=n223 Y=n693
XU523 INVX1 $PINS A=n217 Y=n692
XU524 AOI21X1 $PINS A0=n728 A1=n613 B0=n705 Y=n237
XU525 INVX1 $PINS A=n144 Y=n720
XU526 ADDFX2 $PINS A=n396 B=n403 CI=n394 S=n392 CO=n391
XU527 NAND2X1 $PINS A=FE_OFN44_n5215 B=p2 Y=n274
XU528 XOR2X1 $PINS A=n242 B=n28 Y=product[8]
XU529 NAND2X1 $PINS A=n382 B=n391 Y=n171
XU530 OAI21XL $PINS A0=n111 A1=n691 B0=n112 Y=n110
XU531 NOR2X1 $PINS A=n159 B=n87 Y=n85
XU532 NAND2X2 $PINS A=n190 B=n198 Y=n188
XU533 XOR3X2 $PINS A=n405 B=n398 C=n400 Y=n394
XU535 OAI2BB1X1 $PINS A0N=n144 A1N=n614 B0=n135 Y=n129
XU536 NAND2X1 $PINS A=n665 B=n167 Y=n165
XU537 AOI21XL $PINS A0=n699 A1=n100 B0=n101 Y=n99
XU538 INVX2 $PINS A=n160 Y=n699
XU539 NAND2BX1 $PINS AN=n180 B=n635 Y=n172
XU540 NAND2X1 $PINS A=n486 B=n487 Y=n246
XU541 NOR2X1 $PINS A=n365 B=n358 Y=n145
XU542 NAND2BX1 $PINS AN=n691 B=n179 Y=n635
XU543 NAND2XL $PINS A=n700 B=n100 Y=n98
XU544 NAND2X1 $PINS A=n400 B=n398 Y=n621
XU546 OAI21XL $PINS A0=n720 A1=n119 B0=n120 Y=n114
XU547 OAI21XL $PINS A0=n691 A1=n98 B0=n99 Y=n97
XU549 AOI21X1 $PINS A0=n698 A1=n611 B0=n694 Y=n224
XU550 INVX1 $PINS A=n228 Y=n694
XU551 XNOR2X1 $PINS A=n317 B=n316 Y=n4
XU552 AOI21X1 $PINS A0=n697 A1=n608 B0=n728 Y=n242
XU553 INVX1 $PINS A=n246 Y=n728
XU554 OAI21X1 $PINS A0=n691 A1=n126 B0=n127 Y=n125
XU555 NAND2X1 $PINS A=n432 B=n441 Y=n201
XU556 OAI2BB1X1 $PINS A0N=n610 A1N=n702 B0=n274 Y=n605
XU558 NOR2X1 $PINS A=n402 B=n411 Y=n184
XU559 OAI2BB1X1 $PINS A0N=n630 A1N=n187 B0=n138 Y=n136
XU561 AOI21X1 $PINS A0=n714 A1=n180 B0=n713 Y=n167
XU562 INVX1 $PINS A=n170 Y=n714
XU563 AND2X1 $PINS A=n143 B=n614 Y=n128
XU564 XOR2X1 $PINS A=n110 B=n646 Y=product[26]
XU565 NAND3BXL $PINS AN=n691 B=n179 C=n714 Y=n665
XU567 NAND2X1 $PINS A=n450 B=n457 Y=n212
XU568 NAND2XL $PINS A=a[4] B=a[3] Y=n263
XU569 OAI2BB1X2 $PINS A0N=n676 A1N=n697 B0=n237 Y=n235
XU570 XOR2X1 $PINS A=n34 B=n277 Y=product[2]
XU571 AND2X1 $PINS A=n153 B=n723 Y=n682
XU572 NOR2X1 $PINS A=n119 B=n91 Y=n89
XU573 AOI2BB2X1 $PINS A0N=n47 A1N=n43 B0=n315 B1=FE_OFN5868_register_2__18
+ Y=n706
XU574 NOR2BX1 $PINS AN=n182 B=n181 Y=n617
XU575 NAND2X1 $PINS A=n700 B=n723 Y=n148
XU576 OAI2BB1X1 $PINS A0N=n24 A1N=n217 B0=n607 Y=product[12]
XU577 XNOR2X1 $PINS A=n253 B=n644 Y=product[6]
XU578 XOR3X2 $PINS A=FE_OFN5868_register_2__18 B=n315 C=n45 Y=product[33]
XU579 OR2X2 $PINS A=n486 B=n487 Y=n608
XU580 AOI21X1 $PINS A0=n699 A1=n723 B0=n724 Y=n149
XU581 AOI21X1 $PINS A0=n605 A1=n626 B0=n733 Y=n264
XU582 OAI2BB1X1 $PINS A0N=n718 A1N=n624 B0=n124 Y=n656
XU583 INVX1 $PINS A=n656 Y=n120
XU584 OAI21X2 $PINS A0=n648 A1=n195 B0=n196 Y=n194
XU585 OAI31X1 $PINS A0=n84 A1=n46 A2=n43 B0=n706 Y=n38
XU586 NAND2XL $PINS A=n614 B=n135 Y=n12
XU588 AOI21X2 $PINS A0=n190 A1=n199 B0=n191 Y=n189
XU589 OAI21XL $PINS A0=n192 A1=n196 B0=n193 Y=n191
XU590 OAI21X1 $PINS A0=n211 A1=n215 B0=n212 Y=n210
XU591 NAND2BX1 $PINS AN=n214 B=n215 Y=n24
XU592 NOR2X1 $PINS A=n382 B=n391 Y=n170
XU593 NOR2X1 $PINS A=n152 B=n145 Y=n143
XU594 NAND2X1 $PINS A=n465 B=n458 Y=n215
XU595 INVX1 $PINS A=n234 Y=n704
XU596 NOR2X1 $PINS A=n458 B=n465 Y=n214
XU597 XOR2X1 $PINS A=p2 B=FE_OFN5786_register_2__6 Y=n657
XU598 XOR2X1 $PINS A=p6 B=n657 Y=n486
XU599 NAND2XL $PINS A=p2 B=p6 Y=n658
XU600 NAND2XL $PINS A=p5 B=p6 Y=n659
XU601 NAND2XL $PINS A=p5 B=p2 Y=n660
XU602 NAND3X1 $PINS A=n660 B=n658 C=n659 Y=n485
XU603 XOR2X1 $PINS A=n413 B=n406 Y=n661
XU604 XOR2X1 $PINS A=n404 B=n661 Y=n402
XU605 NAND2X1 $PINS A=n413 B=n404 Y=n662
XU606 NAND2X1 $PINS A=n406 B=n404 Y=n663
XU607 NAND2XL $PINS A=n406 B=n413 Y=n664
XU608 NAND3X1 $PINS A=n664 B=n662 C=n663 Y=n401
XU609 ADDFX2 $PINS A=a[17] B=n419 CI=n417 S=n406 CO=n405
XU610 ADDFX2 $PINS A=n418 B=n420 CI=n425 S=n414 CO=n413
XU611 ADDFX2 $PINS A=n408 B=n410 CI=n415 S=n404 CO=n403
XU612 NAND2X1 $PINS A=n402 B=n411 Y=n185
XU613 XNOR2X1 $PINS A=n165 B=n15 Y=product[21]
XU614 XOR2X1 $PINS A=n451 B=n453 Y=n666
XU615 NAND2X1 $PINS A=n451 B=n444 Y=n667
XU616 NAND2XL $PINS A=n453 B=n451 Y=n669
XU617 ADDFHX1 $PINS A=n463 B=n461 CI=n454 S=n452 CO=n451
XU618 ADDFHX2 $PINS A=n455 B=n446 CI=n448 S=n444 CO=n443
XU619 AOI21X2 $PINS A0=n694 A1=n612 B0=n693 Y=n219
XU620 NAND2XL $PINS A=n700 B=n128 Y=n126
XU621 AOI21X1 $PINS A0=n699 A1=n128 B0=n129 Y=n127
XU623 ADDHX1 $PINS A=FE_OFN5786_register_2__6 B=a[5] S=n488 CO=n487
XU624 OAI21XL $PINS A0=n163 A1=n171 B0=n164 Y=n162
XU625 ADDFX2 $PINS A=p17 B=p13 CI=p11 S=n346 CO=n345
XU627 NAND2X1 $PINS A=n179 B=n161 Y=n159
XU628 NAND2BX1 $PINS AN=n163 B=n164 Y=n15
XU629 NOR2X1 $PINS A=n170 B=n163 Y=n161
XU630 NOR2X1 $PINS A=n381 B=n374 Y=n163
XU631 NAND3X2 $PINS A=n674 B=n672 C=n673 Y=n459
XU632 AND2X2 $PINS A=n626 B=n609 Y=n684
XU633 ADDFX2 $PINS A=a[9] B=a[15] CI=n732 S=n438 CO=n437
XU635 ADDFX2 $PINS A=a[15] B=n439 CI=n437 S=n426 CO=n425
XU636 XNOR2X1 $PINS A=a[11] B=p10 Y=n464
XU637 ADDFX2 $PINS A=_register_2_10 B=a[5] CI=n475 S=n468 CO=n467
XU638 OR2X2 $PINS A=_register_2_10 B=a[4] Y=n475
XU639 ADDFX2 $PINS A=a[9] B=n483 CI=n480 S=n478 CO=n477
XU640 ADDFX2 $PINS A=n476 B=n479 CI=n474 S=n472 CO=n471
XU641 XNOR2X1 $PINS A=_register_2_10 B=a[4] Y=n476
XU642 ADDFX2 $PINS A=n416 B=n423 CI=n414 S=n412 CO=n411
XU643 NAND2X1 $PINS A=n466 B=n471 Y=n223
XU644 NAND2BX1 $PINS AN=n683 B=n252 Y=n250
XU646 NAND2X1 $PINS A=n472 B=n477 Y=n228
XU647 ADDFX2 $PINS A=n395 B=n393 CI=n384 S=n382 CO=n381
XU648 NAND3X1 $PINS A=n621 B=n619 C=n620 Y=n393
XU649 XNOR2X2 $PINS A=n194 B=n640 Y=product[17]
XU650 OR2X2 $PINS A=FE_OFN44_n5215 B=p2 Y=n610
XU651 XOR2X1 $PINS A=n701 B=n31 Y=product[5]
XU652 NAND2X1 $PINS A=n373 B=n366 Y=n153
XU653 NOR2X1 $PINS A=n184 B=n181 Y=n179
XU654 OAI21XL $PINS A0=n145 A1=n153 B0=n146 Y=n144
XU655 INVX1 $PINS A=n135 Y=n718
XU656 NAND2X1 $PINS A=n627 B=n623 Y=n91
XU657 NAND2X1 $PINS A=n610 B=n274 Y=n34
XU658 NAND2X1 $PINS A=p2 B=a[0] Y=n277
XU659 XNOR2X1 $PINS A=n59 B=n5 Y=product[31]
XU660 ADDFX2 $PINS A=p12 B=p17 CI=FE_OFN67_register_2__8 S=n388 CO=n387
XU661 OAI21XL $PINS A0=n87 A1=n160 B0=n88 Y=n86
XU662 XNOR2X2 $PINS A=n213 B=n23 Y=product[13]
XU663 OAI21XL $PINS A0=n692 A1=n214 B0=n215 Y=n213
XU664 XOR2X2 $PINS A=n648 B=n20 Y=product[16]
XU665 NAND2X1 $PINS A=n690 B=n695 Y=n634
XU666 NAND2X1 $PINS A=n611 B=n228 Y=n26
XU667 XNOR2X2 $PINS A=n73 B=n7 Y=product[29]
XU668 ADDFHX1 $PINS A=n473 B=n470 CI=n468 S=n466 CO=n465
XU669 NOR2X1 $PINS A=n478 B=n481 Y=n233
XU670 XNOR2X1 $PINS A=n235 B=n27 Y=product[9]
XU671 XOR2X1 $PINS A=n224 B=n25 Y=product[11]
XU672 XOR2X1 $PINS A=FE_OFN408_n5215 B=n464 Y=n671
XU673 XOR2X1 $PINS A=n469 B=n671 Y=n460
XU674 NAND2X1 $PINS A=FE_OFN408_n5215 B=n469 Y=n672
XU675 NAND2X1 $PINS A=n464 B=n469 Y=n673
XU676 NAND2XL $PINS A=n464 B=FE_OFN408_n5215 Y=n674
XU677 ADDFX2 $PINS A=a[11] B=a[3] CI=FE_OFN12_register_2__1 S=n470 CO=n469
XU678 ADDFX2 $PINS A=a[16] B=_register_2_10 CI=FE_OFN74_register_2__6 S=n428
+ CO=n427
XU679 NOR2X2 $PINS A=n392 B=n401 Y=n181
XU680 AOI21X2 $PINS A0=n690 A1=n198 B0=n199 Y=n648
XU681 XOR2X2 $PINS A=n202 B=n21 Y=product[15]
XU682 OAI21XL $PINS A0=n701 A1=n254 B0=n255 Y=n253
XU683 NAND2X1 $PINS A=n626 B=n268 Y=n686
XU684 XOR2X1 $PINS A=n84 B=n8 Y=product[28]
XU685 ADDHXL $PINS A=p6 B=p12 S=n372 CO=n371
XU686 ADDFX2 $PINS A=n362 B=n360 CI=n367 S=n358 CO=n357
XU687 XOR2X1 $PINS A=n66 B=n643 Y=product[30]
XU688 OAI21XL $PINS A0=n84 A1=n67 B0=n68 Y=n66
XU689 XNOR2X1 $PINS A=n52 B=n4 Y=product[32]
XU690 OAI21XL $PINS A0=n120 A1=n91 B0=n92 Y=n90
XU691 NAND2X1 $PINS A=n89 B=n143 Y=n87
XU692 ADDHXL $PINS A=a[0] B=p6 S=n440 CO=n439
XU693 ADDFX2 $PINS A=p12 B=p5 CI=FE_OFN408_n5215 S=n448 CO=n447
XU694 ADDFX2 $PINS A=n447 B=n438 CI=n436 S=n434 CO=n433
XU695 ADDFX2 $PINS A=a[9] B=a[2] CI=p1 S=n474 CO=n473
XU696 ADDFX2 $PINS A=a[3] B=p2 CI=a[8] S=n480 CO=n479
XU698 ADDFX2 $PINS A=n5383 B=n390 CI=n399 S=n386 CO=n385
XU699 ADDFX2 $PINS A=n397 B=n388 CI=n386 S=n384 CO=n383
XU700 ADDFX2 $PINS A=n387 B=n380 CI=n378 S=n376 CO=n375
XU701 ADDFX2 $PINS A=n364 B=n371 CI=n369 S=n360 CO=n359
XU702 ADDFX2 $PINS A=a[18] B=a[14] CI=a[12] S=n354 CO=n353
XU703 NOR2X1 $PINS A=n675 B=n255 Y=n683
XU704 ADDFX2 $PINS A=n356 B=n631 CI=n361 S=n352 CO=n351
XU705 ADDFX2 $PINS A=a[18] B=a[11] CI=a[14] S=n340 CO=n339
XU706 ADDFX2 $PINS A=n348 B=n355 CI=n353 S=n344 CO=n343
XU707 INVX1 $PINS A=n83 Y=n711
XU708 ADDFX2 $PINS A=a[18] B=a[15] CI=n323 S=n320 CO=n319
XU709 OR2X2 $PINS A=a[3] B=FE_OFN44_n5215 Y=n626
XU710 OR2X2 $PINS A=a[4] B=a[3] Y=n609
XU711 NAND2X1 $PINS A=n478 B=n481 Y=n234
XU712 ADDFX2 $PINS A=n339 B=n332 CI=n337 S=n330 CO=n329
XU713 AND2X2 $PINS A=n634 B=n206 Y=n202
XU714 NAND2X1 $PINS A=n342 B=n349 Y=n124
XU715 OR2X2 $PINS A=n342 B=n349 Y=n624
XU716 NAND2X1 $PINS A=n612 B=n223 Y=n25
XU717 NAND2X1 $PINS A=n336 B=n341 Y=n109
XU718 OR2X2 $PINS A=n336 B=n341 Y=n627
XU720 XOR2X1 $PINS A=n154 B=n682 Y=product[22]
XU721 XNOR2X1 $PINS A=n97 B=n638 Y=product[27]
XU722 AOI21X1 $PINS A0=n89 A1=n144 B0=n90 Y=n88
XU723 NAND2X1 $PINS A=n636 B=n149 Y=n147
XU724 OR2X2 $PINS A=n148 B=n691 Y=n636
XU725 NOR2BX2 $PINS AN=n185 B=n637 Y=n616
XU726 NOR2BX1 $PINS AN=n187 B=n184 Y=n637
XU727 NAND2X1 $PINS A=a[5] B=a[4] Y=n255
XU728 INVX1 $PINS A=n263 Y=n731
XU729 NAND2X1 $PINS A=n609 B=n263 Y=n32
XU731 NOR2X1 $PINS A=n488 B=a[0] Y=n675
XU732 AND2X2 $PINS A=n613 B=n608 Y=n676
XU734 NAND2BX1 $PINS AN=n192 B=n193 Y=n640
XU735 NAND2X1 $PINS A=n692 B=n689 Y=n607
XU737 NAND2X1 $PINS A=n613 B=n241 Y=n28
XU739 NAND2BX1 $PINS AN=n200 B=n201 Y=n21
XU740 NAND2BX1 $PINS AN=n254 B=n255 Y=n31
XU741 INVX1 $PINS A=n233 Y=n703
XU742 AOI21X4 $PINS A0=n85 A1=n187 B0=n86 Y=n84
XU743 INVX1 $PINS A=a[3] Y=n732
XU744 OAI21XL $PINS A0=n102 A1=n720 B0=n103 Y=n101
XU745 XNOR2X2 $PINS A=n125 B=n641 Y=product[25]
XU746 NAND2X1 $PINS A=n412 B=n421 Y=n193
XU747 ADDFX2 $PINS A=p5 B=a[4] CI=p1 S=n462 CO=n461
XU748 XOR2X1 $PINS A=n264 B=n32 Y=product[4]
XU749 XNOR2X1 $PINS A=n690 B=n685 Y=product[14]
XU750 ADDFHX2 $PINS A=n456 B=n459 CI=n452 S=n450 CO=n449
XU751 AOI21X1 $PINS A0=n609 A1=n733 B0=n731 Y=n259
XU752 NAND2BX1 $PINS AN=n233 B=n234 Y=n27
XU753 OR2X2 $PINS A=n482 B=n485 Y=n613
XU754 NAND2X1 $PINS A=n612 B=n611 Y=n218
XU755 OR2X2 $PINS A=n472 B=n477 Y=n611
XU757 XOR2X2 $PINS A=n691 B=n18 Y=product[18]
XU759 AOI21X1 $PINS A0=n699 A1=n143 B0=n144 Y=n138
XU760 AOI21X1 $PINS A0=n699 A1=n113 B0=n114 Y=n112
XU761 NOR2X1 $PINS A=n214 B=n211 Y=n209
XU762 OAI21X1 $PINS A0=n206 A1=n200 B0=n201 Y=n199
XU763 XNOR2X2 $PINS A=n172 B=n16 Y=product[20]
XU764 OR2X2 $PINS A=n466 B=n471 Y=n612
XU767 XNOR2X2 $PINS A=n616 B=n617 Y=product[19]
XU768 ADDFX2 $PINS A=n462 B=n467 CI=n460 S=n458 CO=n457
XU769 NOR2X2 $PINS A=n450 B=n457 Y=n211
XU770 NOR2X1 $PINS A=n192 B=n195 Y=n190
XU771 OAI21X4 $PINS A0=FE_OFN6073_n230 A1=n218 B0=n219 Y=n217
XU772 AOI21X4 $PINS A0=n235 A1=n703 B0=n704 Y=n230
XU773 XNOR2X1 $PINS A=n605 B=n686 Y=product[3]
XU774 OAI2BB1X2 $PINS A0N=n605 A1N=n684 B0=n259 Y=n257
XU775 NOR2X1 $PINS A=n200 B=n205 Y=n198
XU776 NAND2X1 $PINS A=n335 B=n330 Y=n96
XU777 NAND2XL $PINS A=n625 B=n83 Y=n8
XU778 NAND2XL $PINS A=n608 B=n246 Y=n29
XU779 NAND2BXL $PINS AN=n119 B=n627 Y=n102
XU780 INVXL $PINS A=n625 Y=n710
XU781 NAND2BXL $PINS AN=n71 B=n72 Y=n7
XU782 NAND2XL $PINS A=n62 B=n625 Y=n60
XU783 INVXL $PINS A=n71 Y=n709
XU784 NAND2BXL $PINS AN=n675 B=n252 Y=n644
XU785 NAND2X1 $PINS A=n381 B=n374 Y=n164
XU786 NAND2XL $PINS A=n325 B=n322 Y=n72
XU787 AOI22XL $PINS A0=n325 A1=n322 B0=n711 B1=n709 Y=n68
XU788 NAND2XL $PINS A=n55 B=n628 Y=n46
XU789 NAND2X1 $PINS A=n482 B=n485 Y=n241
XU790 ADDFX2 $PINS A=n372 B=n379 CI=n370 S=n368 CO=n367
XU791 AOI22XL $PINS A0=n56 A1=n628 B0=n317 B1=n316 Y=n47
XU792 NOR2XL $PINS A=n315 B=FE_OFN5868_register_2__18 Y=n43
XU793 NOR2X1 $PINS A=n721 B=n119 Y=n113
XU794 NOR2X1 $PINS A=n721 B=n102 Y=n100
XU795 INVXL $PINS A=n143 Y=n721
XU796 NAND2BX1 $PINS AN=n195 B=n196 Y=n20
XU797 INVXL $PINS A=n153 Y=n724
XU798 INVX1 $PINS A=n24 Y=n689
XU799 NAND2BXL $PINS AN=n145 B=n146 Y=n13
XU800 NAND2BXL $PINS AN=n184 B=n185 Y=n18
XU801 NAND2X1 $PINS A=n624 B=n124 Y=n641
XU802 INVXL $PINS A=n152 Y=n723
XU803 AOI21X1 $PINS A0=n623 A1=n716 B0=n715 Y=n92
XU804 INVX1 $PINS A=n96 Y=n715
XU805 AOI21X1 $PINS A0=n656 A1=n627 B0=n716 Y=n103
XU806 NAND2X1 $PINS A=n623 B=n96 Y=n638
XU808 OAI21XL $PINS A0=n691 A1=n159 B0=n160 Y=n154
XU809 NAND2XL $PINS A=n700 B=n113 Y=n111
XU810 INVX1 $PINS A=n109 Y=n716
XU811 INVX1 $PINS A=n55 Y=n707
XU812 INVX1 $PINS A=n56 Y=n708
XU813 INVXL $PINS A=n171 Y=n713
XU814 INVX1 $PINS A=n241 Y=n705
XU815 NOR2X1 $PINS A=n675 B=n254 Y=n249
XU816 NAND2X1 $PINS A=n422 B=n431 Y=n196
XU817 NAND2X1 $PINS A=n392 B=n401 Y=n182
XU818 NOR2X1 $PINS A=n325 B=n322 Y=n71
XU819 AOI21X1 $PINS A0=n62 A1=n711 B0=n63 Y=n61
XU820 OAI21XL $PINS A0=n72 A1=n64 B0=n65 Y=n63
XU821 OAI21XL $PINS A0=n61 A1=n57 B0=n58 Y=n56
XU822 OR2X2 $PINS A=n329 B=n326 Y=n625
XU823 NOR2X1 $PINS A=n71 B=n64 Y=n62
XU824 NAND2X1 $PINS A=n357 B=n350 Y=n135
XU825 NAND2X1 $PINS A=n329 B=n326 Y=n83
XU826 NOR2X1 $PINS A=n60 B=n57 Y=n55
XU827 OR2X2 $PINS A=n357 B=n350 Y=n614
XU828 OR2X2 $PINS A=n335 B=n330 Y=n623
XU829 OAI21XL $PINS A0=n84 A1=n46 B0=n47 Y=n45
XU830 NAND2X1 $PINS A=n365 B=n358 Y=n146
XU831 NAND2BX1 $PINS AN=n57 B=n58 Y=n5
XU832 OAI21XL $PINS A0=n84 A1=n60 B0=n61 Y=n59
XU833 NOR2BX1 $PINS AN=n65 B=n64 Y=n643
XU834 NAND2X1 $PINS A=n625 B=n709 Y=n67
XU835 ADDFX2 $PINS A=n428 B=n430 CI=n435 S=n424 CO=n423
XU836 ADDFX2 $PINS A=a[16] B=n429 CI=n427 S=n416 CO=n415
XU838 ADDFX2 $PINS A=n333 B=n328 CI=n331 S=n326 CO=n325
XU840 ADDFX2 $PINS A=p15 B=n324 CI=n327 S=n322 CO=n321
XU841 NOR2X1 $PINS A=n321 B=n320 Y=n64
XU842 NOR2X1 $PINS A=n319 B=n318 Y=n57
XU843 ADDFX2 $PINS A=n346 B=n351 CI=n344 S=n342 CO=n341
XU844 ADDFX2 $PINS A=n340 B=n343 CI=n338 S=n336 CO=n335
XU845 ADDFX2 $PINS A=n354 B=n359 CI=n352 S=n350 CO=n349
XU846 ADDHXL $PINS A=a[9] B=a[16] S=n356 CO=n355
XU847 ADDFX2 $PINS A=p15 B=p13 CI=n334 S=n332 CO=n331
XU848 NAND2X1 $PINS A=n321 B=n320 Y=n65
XU849 OAI21XL $PINS A0=n84 A1=n707 B0=n708 Y=n52
XU850 NAND2XL $PINS A=n400 B=n405 Y=n620
XU851 NAND2XL $PINS A=n398 B=n405 Y=n619
XU852 ADDFX2 $PINS A=p14 B=n347 CI=n345 S=n338 CO=n337
XU855 OR2X2 $PINS A=n317 B=n316 Y=n628
XU856 NAND2X1 $PINS A=n319 B=n318 Y=n58
XU858 ADDFX2 $PINS A=p2 B=p7 CI=p3 S=n430 CO=n429
XU859 ADDFX2 $PINS A=a[18] B=p10 CI=FE_OFN67_register_2__8 S=n408 CO=n407
XU860 ADDFX2 $PINS A=p10 B=p6 CI=n732 S=n454 CO=n453
XU862 ADDFX2 $PINS A=p17 B=a[16] CI=p16 S=n318 CO=n317
XU863 ADDFX2 $PINS A=a[3] B=_register_2_10 CI=FE_OFN74_register_2__6 S=n410
+ CO=n409
XU864 ADDHXL $PINS A=FE_OFN72_register_2__14 B=FE_RN_1 S=n324 CO=n323
XU866 ADDHXL $PINS A=_register_2_10 B=a[17] S=n348 CO=n347
XU871 ADDFX2 $PINS A=a[13] B=p9 CI=n632 S=n378 CO=n377
XU872 ADDFX2 $PINS A=a[13] B=p16 CI=p14 S=n328 CO=n327
XU873 XNOR2X1 $PINS A=n38 B=n2 Y=product[34]
XU874 XNOR2XL $PINS A=FE_RN_1 B=a[18] Y=n2
XU875 ADDHXL $PINS A=a[17] B=FE_RN_1 S=n316 CO=n315
XU876 ADDFX2 $PINS A=a[13] B=p7 CI=p3 S=n446 CO=n445
XU877 NAND2XL $PINS A=n488 B=a[0] Y=n252
XU878 AND2X1 $PINS A=FE_OFN77_register_2__5 B=p10 Y=n632
XU879 XOR2X1 $PINS A=FE_OFN77_register_2__5 B=p10 Y=n390
XU880 ADDFX2 $PINS A=a[13] B=a[5] CI=FE_OFN12_register_2__1 S=n456 CO=n455
XU881 ADDFX2 $PINS A=a[15] B=p5 CI=p8 S=n380 CO=n379
XU882 ADDFX2 $PINS A=a[17] B=a[11] CI=a[7] S=n418 CO=n417
XU883 OR2XL $PINS A=p2 B=a[0] Y=n645
XU884 ADDHXL $PINS A=p17 B=p10 S=n334 CO=n333
XU885 ADDFX2 $PINS A=p17 B=a[13] CI=p8 S=n398 CO=n397
XU886 NAND2BXL $PINS AN=n211 B=n212 Y=n23
XU887 ADDFX2 $PINS A=a[4] B=a[11] CI=a[7] S=n400 CO=n399
XU888 OR2XL $PINS A=a[11] B=p10 Y=n463
XU889 AND2X1 $PINS A=p7 B=a[15] Y=n631
XU890 XOR2X1 $PINS A=p7 B=a[15] Y=n364
.ENDS

.SUBCKT CONV_DW_mult_uns_29 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[13] b[12]
+ b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0] product[33]
+ product[32] product[31] product[30] product[29] product[28] product[27]
+ product[26] product[25] product[24] product[23] product[22] product[21]
+ product[20] product[19] product[18] product[17] product[16] product[15]
+ product[14] product[13] product[12] product[11] product[10] product[9]
+ product[8] product[7] product[6] product[5] product[4] product[3] product[2]
+ product[1] product[0] n5475 n5214 n5383 _register_2_10 p1 p2 p3 p4 p5 p6 p7
+ p8 p9 p10 p11 p12 p13 p14 p15 p16 p17 FE_OFN2_register_2__4
+ FE_OFN4_register_2__8 FE_OFN3_register_2__8 FE_OFN43_register_2__6
+ FE_OFN42_register_2__6 FE_OFN48_register_2__5 FE_OFN51_register_2__1
+ FE_OFN312_register_2__18 p18 FE_OFN71_register_2__14 FE_OFN73_register_2__10
+ FE_OFN79_register_2__18
XFE_RC_664_0 OAI22X1 $PINS A0=n897 A1=a[6] B0=n898 B1=FE_OFN42_register_2__6
+ Y=n970
XFE_RC_642_0 INVX1 $PINS A=n840 Y=FE_RN_348_0
XFE_RC_641_0 NAND2BX1 $PINS AN=n591 B=FE_RN_348_0 Y=FE_RN_349_0
XFE_RC_640_0 CLKINVX8 $PINS A=FE_RN_350_0 Y=n763
XFE_RC_639_0 AND3X4 $PINS A=n841 B=n842 C=FE_RN_349_0 Y=FE_RN_350_0
XFE_OFC1881_n967 INVX1 $PINS A=n860 Y=FE_OFN5927_n967
XFE_OFC1880_n967 INVX1 $PINS A=n967 Y=n860
XFE_OFC1810_n688 INVX1 $PINS A=n658 Y=FE_OFN5893_n688
XFE_OFC1809_n688 INVX1 $PINS A=n688 Y=n658
XFE_OFC1793_N567 INVX1 $PINS A=p1 Y=FE_OFN5884_N567
XFE_OFC1767_register_2__18 BUFX3 $PINS A=FE_OFN312_register_2__18
+ Y=FE_OFN5869_register_2__18
XFE_OFC1753_n730 INVXL $PINS A=n730 Y=FE_OFN5861_n730
XFE_OFC1709_n721 INVX1 $PINS A=n653 Y=FE_OFN5837_n721
XFE_OFC1708_n721 INVX1 $PINS A=n721 Y=n653
XFE_OFC1670_register_2__11 INVX1 $PINS A=a[11] Y=FE_OFN5817_register_2__11
XFE_OFC1573_register_2__4 INVX1 $PINS A=a[4] Y=FE_RN_1
XFE_OFC1550_register_2__8 INVX1 $PINS A=a[8] Y=FE_OFN5754_register_2__8
XFE_OFC1383_n943 INVX1 $PINS A=n838 Y=FE_OFN5664_n943
XFE_OFC1382_n943 INVX1 $PINS A=n943 Y=n838
XFE_OFC598_n795 INVX1 $PINS A=n795 Y=n740
XFE_OFC374_n554 INVX1 $PINS A=n554 Y=n936
XFE_OFC251_n621 INVXL $PINS A=n621 Y=n588
XU439 OAI21X2 $PINS A0=n627 A1=n587 B0=n630 Y=n629
XU490 OAI221X2 $PINS A0=n601 A1=n681 B0=n682 B1=n681 C0=n683 Y=n668
XU493 OAI21X1 $PINS A0=n689 A1=n688 B0=n690 Y=n687
XU519 AOI31X1 $PINS A0=n692 A1=n628 A2=n718 B0=n633 Y=n705
XU520 AOI32X2 $PINS A0=n719 A1=n720 A2=n692 B0=FE_OFN5837_n721 B1=n657 Y=n689
XU538 NAND2X2 $PINS A=n653 B=n722 Y=n692
XU547 OAI21XL $PINS A0=n751 A1=n747 B0=n748 Y=n721
XU561 OAI21X1 $PINS A0=n759 A1=n760 B0=n761 Y=n750
XU566 OAI211X1 $PINS A0=n766 A1=n605 B0=n767 C0=n768 Y=n765
XU578 XOR2X2 $PINS A=n669 B=p15 Y=n760
XU579 NOR2X2 $PINS A=n661 B=n732 Y=n669
XU592 AOI22X1 $PINS A0=n791 A1=n792 B0=n774 B1=n793 Y=n790
XU608 NOR2X2 $PINS A=p9 B=FE_OFN79_register_2__18 Y=n746
XU614 OR2X2 $PINS A=n792 B=n791 Y=n774
XU616 XOR2X2 $PINS A=n811 B=n796 Y=n792
XU635 OAI2BB1X1 $PINS A0N=n820 A1N=n788 B0=n822 Y=n821
XU687 NOR2X1 $PINS A=n874 B=n873 Y=n849
XU705 NOR2X1 $PINS A=n870 B=n871 Y=n846
XU722 AND2X2 $PINS A=n906 B=n907 Y=n909
XU776 XNOR2X2 $PINS A=n961 B=n594 Y=n937
XU791 OAI211X1 $PINS A0=n970 A1=n606 B0=n608 C0=n607 Y=n969
XU793 OAI21XL $PINS A0=n929 A1=n853 B0=n972 Y=n608
XU820 XNOR2X1 $PINS A=a[1] B=n5475 Y=n614
XU414 OAI2BB1X1 $PINS A0N=n901 A1N=n902 B0=n903 Y=n888
XU415 OAI2BB1X2 $PINS A0N=n840 A1N=n591 B0=n847 Y=n841
XU418 NOR2X1 $PINS A=n776 B=n775 Y=n766
XU419 NAND2X1 $PINS A=n684 B=n685 Y=n530
XU420 NAND2XL $PINS A=n686 B=n687 Y=n531
XU421 AND2X2 $PINS A=n530 B=n531 Y=n683
XU422 NAND2XL $PINS A=n718 B=n628 Y=n532
XU423 NAND2XL $PINS A=n719 B=n720 Y=n533
XU424 AND2X2 $PINS A=n532 B=n533 Y=n738
XU425 INVX1 $PINS A=n739 Y=n628
XU426 OAI2BB1X1 $PINS A0N=n752 A1N=n753 B0=n754 Y=n720
XU427 OR2X2 $PINS A=n588 B=n622 Y=n534
XU428 OR2XL $PINS A=a[18] B=n620 Y=n535
XU429 OR2X1 $PINS A=n621 B=a[18] Y=n536
XU430 NAND3X2 $PINS A=n534 B=n535 C=n536 Y=product[32]
XU431 NAND2XL $PINS A=n620 B=a[18] Y=n622
XU433 AOI21XL $PINS A0=n946 A1=n838 B0=n929 Y=n944
XU434 XOR2X1 $PINS A=a[9] B=n902 Y=n946
XU435 OAI21XL $PINS A0=p4 A1=a[12] B0=n807 Y=n783
XU437 XNOR2X1 $PINS A=p2 B=a[4] Y=n898
XU440 OAI21XL $PINS A0=n815 A1=n816 B0=n817 Y=n799
XU441 OAI2BB1X1 $PINS A0N=n816 A1N=n815 B0=n818 Y=n817
XU442 AOI21XL $PINS A0=n729 A1=n730 B0=n731 Y=n728
XU443 AOI2BB1X1 $PINS A0N=a[13] A1N=n746 B0=n677 Y=n731
XU444 NOR2BX1 $PINS AN=n679 B=n678 Y=n696
XU445 NOR2X1 $PINS A=p13 B=a[17] Y=n678
XU446 NOR2X1 $PINS A=p3 B=a[1] Y=n878
XU448 OAI2BB1X1 $PINS A0N=n609 A1N=n805 B0=n606 Y=n968
XU449 OAI21XL $PINS A0=n781 A1=n716 B0=n782 Y=n752
XU450 OAI2BB1X1 $PINS A0N=n716 A1N=n781 B0=n783 Y=n782
XU451 AOI21X1 $PINS A0=n773 A1=n763 B0=n793 Y=n809
XU454 NOR2BX1 $PINS AN=n879 B=n878 Y=n897
XU456 OAI21XL $PINS A0=a[3] A1=p2 B0=a[8] Y=n962
XU457 OAI21XL $PINS A0=n5475 A1=p2 B0=FE_OFN48_register_2__5 Y=n928
XU459 OAI2BB1X1 $PINS A0N=FE_OFN5884_N567 A1N=n966 B0=n975 Y=n957
XU460 OAI21XL $PINS A0=FE_OFN5884_N567 A1=n966 B0=p4 Y=n975
XU461 XOR2X1 $PINS A=n965 B=n966 Y=n603
XU462 OAI21XL $PINS A0=a[6] A1=n878 B0=n879 Y=n966
XU464 AOI21X1 $PINS A0=a[16] A1=a[9] B0=n712 Y=n730
XU465 NOR2X1 $PINS A=a[9] B=a[16] Y=n712
XU466 XOR2X1 $PINS A=n886 B=n888 Y=n573
XU468 XOR2X1 $PINS A=n576 B=n820 Y=n825
XU469 XNOR2X1 $PINS A=p6 B=FE_OFN5884_N567 Y=n902
XU470 OAI21XL $PINS A0=_register_2_10 A1=n930 B0=n931 Y=n924
XU471 XNOR2X1 $PINS A=n929 B=FE_OFN42_register_2__6 Y=n922
XU472 INVX1 $PINS A=n649 Y=n599
XU476 OAI21XL $PINS A0=p12 A1=n5383 B0=p6 Y=n758
XU477 OAI21XL $PINS A0=a[1] A1=n5475 B0=n962 Y=n943
XU479 AOI2BB1X1 $PINS A0N=n933 A1N=n934 B0=n935 Y=n907
XU480 INVX1 $PINS A=n612 Y=n853
XU481 INVX1 $PINS A=n970 Y=n805
XU483 XOR2X1 $PINS A=n859 B=n831 Y=n837
XU484 OAI2BB1X1 $PINS A0N=n855 A1N=n854 B0=n857 Y=n856
XU485 XNOR2X1 $PINS A=n572 B=n890 Y=product[15]
XU486 INVX1 $PINS A=n929 Y=n828
XU489 INVX1 $PINS A=n669 Y=n876
XU492 OAI21XL $PINS A0=n865 A1=n864 B0=n867 Y=n866
XU494 INVX1 $PINS A=n766 Y=n610
XU495 XOR2X1 $PINS A=n618 B=n619 Y=product[33]
XU496 OAI21X1 $PINS A0=n705 A1=FE_OFN5893_n688 B0=n690 Y=n704
XU497 MXI2X1 $PINS S0=FE_OFN73_register_2__10 B=n914 A=n915 Y=n547
XU498 OAI21XL $PINS A0=n921 A1=n922 B0=n923 Y=n912
XU499 XOR3X2 $PINS A=n755 B=n752 C=n753 Y=n775
XU500 XOR3X2 $PINS A=n709 B=n706 C=n707 Y=n723
XU501 XOR3X2 $PINS A=n930 B=FE_OFN4_register_2__8 C=FE_OFN73_register_2__10
+ Y=n934
XU503 NOR2X1 $PINS A=n720 B=n719 Y=n739
XU504 XOR3X2 $PINS A=n881 B=n883 C=n880 Y=n885
XU505 XNOR3X2 $PINS A=n818 B=n816 C=n815 Y=n820
XU506 AOI2BB1X1 $PINS A0N=n837 A1N=n836 B0=n541 Y=n778
XU507 INVX1 $PINS A=n839 Y=n541
XU508 XOR3X2 $PINS A=n762 B=n760 C=n759 Y=n753
XU509 OAI21X1 $PINS A0=n788 A1=n820 B0=n821 Y=n791
XU510 INVX1 $PINS A=n823 Y=n788
XU511 OAI21XL $PINS A0=n785 A1=n784 B0=n787 Y=n786
XU512 XNOR3X2 $PINS A=n742 B=n741 C=n744 Y=n747
XU513 XOR3X2 $PINS A=n803 B=n804 C=n801 Y=n796
XU514 XOR3X2 $PINS A=n729 B=n730 C=n731 Y=n734
XU515 XOR3X2 $PINS A=a[12] B=n901 C=n902 Y=n892
XU516 MXI2X2 $PINS S0=n5383 B=n696 A=n697 Y=n804
XU517 XOR2X1 $PINS A=n698 B=a[13] Y=n742
XU518 NAND3BX1 $PINS AN=n766 B=n737 C=n769 Y=n768
XU521 OAI2BB1X1 $PINS A0N=n742 A1N=n741 B0=n744 Y=n743
XU522 XNOR3X2 $PINS A=n785 B=n787 C=n784 Y=n794
XU523 XOR3X2 $PINS A=n5383 B=a[17] C=a[13] Y=n713
XU526 INVX1 $PINS A=n689 Y=n633
XU527 OAI2BB1X1 $PINS A0N=n796 A1N=n757 B0=n798 Y=n797
XU528 NAND2BX1 $PINS AN=n612 B=n928 Y=n916
XU529 OR2X2 $PINS A=a[15] B=p15 Y=n679
XU530 OAI2BB1X1 $PINS A0N=n5383 A1N=p12 B0=n758 Y=n744
XU531 NOR2BX2 $PINS AN=p10 B=p18 Y=n732
XU532 OAI2BB1X1 $PINS A0N=n885 A1N=n886 B0=n887 Y=n874
XU533 OAI2BB1X2 $PINS A0N=n548 A1N=n763 B0=n601 Y=n718
XU534 CLKINVX3 $PINS A=n765 Y=n601
XU535 OAI2BB1X1 $PINS A0N=a[13] A1N=a[6] B0=n780 Y=n762
XU536 OAI21XL $PINS A0=n881 A1=n880 B0=n883 Y=n882
XU537 XOR2X1 $PINS A=n669 B=FE_OFN71_register_2__14 Y=n733
XU539 XNOR3X2 $PINS A=n792 B=n809 C=n791 Y=product[19]
XU540 NOR2X1 $PINS A=n740 B=n794 Y=n772
XU541 NAND2X1 $PINS A=n919 B=n920 Y=n901
XU542 XNOR3X2 $PINS A=n924 B=n922 C=n921 Y=n906
XU543 AOI2BB2X1 $PINS A0N=p18 A1N=p15 B0=n620 B1=FE_OFN71_register_2__14 Y=n640
XU544 XOR3X2 $PINS A=n867 B=n864 C=n865 Y=n873
XU545 OAI21XL $PINS A0=n914 A1=FE_OFN5884_N567 B0=n562 Y=n971
XU546 NAND3X2 $PINS A=n610 B=n763 C=n764 Y=n682
XU548 XOR3X2 $PINS A=n892 B=n894 C=n547 Y=n911
XU549 AND2X2 $PINS A=p6 B=p1 Y=n881
XU550 NAND2X1 $PINS A=n645 B=n646 Y=n544
XU551 NAND2XL $PINS A=n559 B=n905 Y=n932
XU552 OAI21XL $PINS A0=n828 A1=n612 B0=n596 Y=n972
XU553 INVX1 $PINS A=n973 Y=n596
XU554 XNOR3X2 $PINS A=n700 B=n702 C=n711 Y=n686
XU555 XNOR3X2 $PINS A=n740 B=n794 C=n789 Y=product[20]
XU556 XOR3X2 $PINS A=n855 B=n857 C=n854 Y=n865
XU557 XOR2X1 $PINS A=n871 B=n870 Y=n890
XU558 XOR3X2 $PINS A=n932 B=n907 C=n906 Y=product[13]
XU559 MXI2X1 $PINS S0=n677 B=n697 A=n696 Y=n672
XU560 OAI21XL $PINS A0=n706 A1=n707 B0=n708 Y=n685
XU562 XNOR3X2 $PINS A=n971 B=n919 C=n608 Y=product[7]
XU563 NAND2XL $PINS A=p2 B=a[0] Y=n616
XU564 XOR3X2 $PINS A=n624 B=n623 C=n629 Y=product[31]
XU565 XOR3X2 $PINS A=n718 B=n719 C=n720 Y=product[22]
XU567 OAI21XL $PINS A0=FE_RN_1 A1=FE_OFN5817_register_2__11 B0=n814 Y=n803
XU568 AOI21X1 $PINS A0=n934 A1=n933 B0=n936 Y=n935
XU570 OAI2BB1X1 $PINS A0N=n713 A1N=n712 B0=p13 Y=n714
XU571 XOR3X2 $PINS A=n604 B=n606 C=n970 Y=product[8]
XU572 AOI211X1 $PINS A0=n695 A1=n669 B0=n674 C0=n671 Y=n646
XU573 OAI2BB1X1 $PINS A0N=n930 A1N=_register_2_10 B0=FE_OFN4_register_2__8
+ Y=n931
XU574 XOR3X2 $PINS A=n783 B=n716 C=n781 Y=n785
XU575 XNOR3X2 $PINS A=n837 B=n839 C=n836 Y=n840
XU576 XNOR3X2 $PINS A=n648 B=n660 C=n645 Y=product[28]
XU577 XOR3X2 $PINS A=n686 B=n704 C=n685 Y=product[25]
XU580 XOR2X1 $PINS A=n927 B=n916 Y=n921
XU581 NOR2BX1 $PINS AN=n900 B=n899 Y=n914
XU582 OAI2BB1X1 $PINS A0N=a[15] A1N=FE_OFN3_register_2__8 B0=p11 Y=n835
XU583 OAI21XL $PINS A0=a[14] A1=a[12] B0=a[7] Y=n858
XU585 AND2X1 $PINS A=n851 B=n592 Y=n571
XU586 OAI2BB1X1 $PINS A0N=n747 A1N=n751 B0=n749 Y=n748
XU587 INVX1 $PINS A=n750 Y=n751
XU588 NAND2X1 $PINS A=n693 B=n694 Y=n667
XU589 XNOR3X2 $PINS A=n638 B=n637 C=n587 Y=product[30]
XU590 AND2X2 $PINS A=n767 B=n610 Y=n565
XU591 OAI21XL $PINS A0=FE_OFN5817_register_2__11 A1=n916 B0=p8 Y=n917
XU593 OAI21XL $PINS A0=n615 A1=n614 B0=n974 Y=n973
XU594 OAI2BB1X1 $PINS A0N=p11 A1N=_register_2_10 B0=n715 Y=n702
XU595 OAI2BB1X1 $PINS A0N=n632 A1N=a[16] B0=n631 Y=n623
XU596 XNOR3X2 $PINS A=n956 B=n957 C=n964 Y=product[10]
XU597 OAI21XL $PINS A0=n876 A1=n672 B0=n673 Y=n670
XU598 XNOR3X2 $PINS A=n847 B=n862 C=n840 Y=product[17]
XU599 XOR3X2 $PINS A=FE_OFN5837_n721 B=n722 C=n738 Y=product[23]
XU600 XOR3X2 $PINS A=p18 B=n640 C=n641 Y=n651
XU601 OAI211X1 $PINS A0=n594 A1=FE_OFN5664_n943 B0=n948 C0=n945 Y=n947
XU602 XOR3X2 $PINS A=n958 B=FE_OFN42_register_2__6 C=n959 Y=n956
XU603 NAND2X1 $PINS A=n873 B=n874 Y=n851
XU604 NOR2X1 $PINS A=n825 B=n826 Y=n793
XU605 NAND2X1 $PINS A=n740 B=n794 Y=n769
XU606 XNOR3X2 $PINS A=n749 B=n750 C=n747 Y=n719
XU607 XNOR3X2 $PINS A=n603 B=FE_OFN5927_n967 C=n600 Y=product[9]
XU609 OAI2BB1X1 $PINS A0N=n759 A1N=n760 B0=n762 Y=n761
XU610 OAI21XL $PINS A0=n899 A1=FE_OFN5884_N567 B0=n900 Y=n606
XU611 OAI2BB1X1 $PINS A0N=FE_OFN71_register_2__14 A1N=n698 B0=p14 Y=n699
XU612 AOI2BB2X2 $PINS A0N=n634 A1N=n635 B0=n651 B1=n652 Y=n587
XU617 XNOR3X2 $PINS A=n734 B=n736 C=n733 Y=n722
XU618 AOI21X1 $PINS A0=FE_OFN5861_n730 A1=n925 B0=n728 Y=n706
XU619 AND3X2 $PINS A=n769 B=n773 C=n774 Y=n764
XU620 NAND2X1 $PINS A=n826 B=n825 Y=n773
XU621 OAI2BB1X1 $PINS A0N=n832 A1N=n831 B0=n834 Y=n833
XU622 XOR2X1 $PINS A=n832 B=n834 Y=n859
XU623 AOI21X1 $PINS A0=n593 A1=n840 B0=n846 Y=n845
XU624 OAI21XL $PINS A0=FE_RN_1 A1=n5214 B0=a[6] Y=n920
XU625 AOI31X4 $PINS A0=n937 A1=n938 A2=n590 B0=n589 Y=n905
XU626 NOR2X1 $PINS A=n603 B=n860 Y=n955
XU627 OAI2BB1X1 $PINS A0N=n547 A1N=n892 B0=n893 Y=n870
XU628 OAI2BB2X1 $PINS A0N=a[18] A1N=n558 B0=FE_OFN5869_register_2__18 B1=n621
+ Y=n618
XU629 NAND2X1 $PINS A=FE_RN_1 B=n5214 Y=n919
XU630 NAND2X1 $PINS A=n911 B=n912 Y=n872
XU631 NAND2X1 $PINS A=n644 B=n599 Y=n543
XU633 AND3X2 $PINS A=n543 B=n544 C=n647 Y=n635
XU636 INVX1 $PINS A=n804 Y=n727
XU637 NOR2X1 $PINS A=n677 B=n746 Y=n698
XU638 XNOR2X1 $PINS A=FE_OFN42_register_2__6 B=a[13] Y=n806
XU639 OAI21XL $PINS A0=_register_2_10 A1=a[3] B0=FE_OFN42_register_2__6 Y=n830
XU640 XNOR2X1 $PINS A=FE_OFN42_register_2__6 B=a[3] Y=n569
XU641 OAI21XL $PINS A0=n831 A1=n832 B0=n833 Y=n823
XU642 XOR2X2 $PINS A=a[13] B=n741 Y=n832
XU643 OAI21XL $PINS A0=n892 A1=n547 B0=n894 Y=n893
XU645 OAI2BB1X1 $PINS A0N=FE_OFN5817_register_2__11 A1N=n916 B0=n917 Y=n894
XU646 AOI21XL $PINS A0=n672 A1=n876 B0=n673 Y=n674
XU647 XOR2XL $PINS A=n876 B=n673 Y=n567
XU650 XNOR2X1 $PINS A=n565 B=n771 Y=product[21]
XU651 AOI221X1 $PINS A0=n764 A1=n763 B0=n737 B1=n769 C0=n772 Y=n771
XU652 OAI21XL $PINS A0=a[2] A1=p4 B0=a[9] Y=n861
XU653 NAND2X1 $PINS A=n5475 B=p4 Y=n900
XU654 XOR2X1 $PINS A=p4 B=n614 Y=n933
XU656 OAI2BB2X1 $PINS A0N=a[7] A1N=FE_OFN5884_N567 B0=a[9] B1=n881 Y=n554
XU659 NAND3X1 $PINS A=n844 B=n551 C=n845 Y=n842
XU660 NAND2X1 $PINS A=a[1] B=p3 Y=n879
XU661 XNOR2X1 $PINS A=p8 B=FE_OFN48_register_2__5 Y=n877
XU662 INVX1 $PINS A=n946 Y=n594
XU664 OR2X2 $PINS A=p1 B=n915 Y=n562
XU665 NOR2X1 $PINS A=a[19] B=p10 Y=n661
XU667 XNOR2X1 $PINS A=n798 B=n799 Y=n811
XU668 OAI21XL $PINS A0=n733 A1=n734 B0=n735 Y=n724
XU669 OAI2BB1X1 $PINS A0N=n734 A1N=n733 B0=n736 Y=n735
XU670 OR2X2 $PINS A=n912 B=n911 Y=n843
XU672 NAND2BX1 $PINS AN=n971 B=n919 Y=n607
XU673 NAND2BX1 $PINS AN=n919 B=n971 Y=n609
XU676 OAI21XL $PINS A0=n753 A1=n752 B0=n755 Y=n754
XU677 OAI2BB1X1 $PINS A0N=n707 A1N=n706 B0=n709 Y=n708
XU678 NOR2X1 $PINS A=n724 B=n723 Y=n688
XU679 NAND2X1 $PINS A=n723 B=n724 Y=n690
XU681 AND2X2 $PINS A=n610 B=n764 Y=n548
XU684 OAI21X1 $PINS A0=n634 A1=n635 B0=n636 Y=n625
XU685 OAI2BB1X1 $PINS A0N=n801 A1N=n727 B0=n803 Y=n802
XU686 OR2X2 $PINS A=n687 B=n686 Y=n684
XU688 AOI21X1 $PINS A0=n644 A1=n650 B0=n646 Y=n660
XU689 OAI222X2 $PINS A0=n905 A1=n906 B0=n907 B1=n908 C0=n910 C1=n909 Y=n844
XU690 XOR2X1 $PINS A=FE_OFN5817_register_2__11 B=n806 Y=n886
XU691 OAI21XL $PINS A0=n5475 A1=FE_OFN73_register_2__10 B0=n830 Y=n818
XU693 XOR2XL $PINS A=a[15] B=n712 Y=n578
XU695 OAI2BB1X1 $PINS A0N=n922 A1N=n921 B0=n924 Y=n923
XU696 INVX1 $PINS A=n672 Y=n695
XU698 INVX1 $PINS A=n947 Y=n589
XU699 XNOR2XL $PINS A=p2 B=p1 Y=product[3]
XU700 INVX1 $PINS A=n620 Y=n558
XU701 INVX1 $PINS A=n847 Y=n593
XU702 NAND2X1 $PINS A=n925 B=n835 Y=n822
XU703 NAND2BX1 $PINS AN=n712 B=n819 Y=n798
XU704 OAI21XL $PINS A0=p14 A1=p8 B0=a[14] Y=n819
XU706 OAI21XL $PINS A0=a[13] A1=a[6] B0=p8 Y=n780
XU708 INVX1 $PINS A=n677 Y=n703
XU709 NOR2X1 $PINS A=FE_OFN312_register_2__18 B=a[11] Y=n677
XU710 OAI21XL $PINS A0=a[13] A1=a[11] B0=n884 Y=n867
XU711 OAI21XL $PINS A0=p11 A1=FE_OFN5817_register_2__11
+ B0=FE_OFN42_register_2__6 Y=n884
XU712 OAI21X1 $PINS A0=n741 A1=n742 B0=n743 Y=n736
XU713 INVX1 $PINS A=n711 Y=n726
XU714 OAI21XL $PINS A0=n712 A1=n713 B0=n714 Y=n711
XU715 OAI21XL $PINS A0=n677 A1=n678 B0=n679 Y=n664
XU716 OR2X2 $PINS A=n685 B=n686 Y=n691
XU717 INVX1 $PINS A=n849 Y=n592
XU718 INVX1 $PINS A=n848 Y=n591
XU719 INVX1 $PINS A=n790 Y=n737
XU720 INVX1 $PINS A=n772 Y=n605
XU721 OAI21XL $PINS A0=_register_2_10 A1=n899 B0=n900 Y=n883
XU723 AND2X2 $PINS A=n843 B=n592 Y=n551
XU725 OAI21XL $PINS A0=n955 A1=n956 B0=n957 Y=n954
XU726 OAI21XL $PINS A0=n727 A1=n801 B0=n802 Y=n784
XU727 OAI2BB1X1 $PINS A0N=n614 A1N=n615 B0=a[2] Y=n974
XU728 NAND4X1 $PINS A=n691 B=n692 C=n658 D=n628 Y=n681
XU730 XOR2X1 $PINS A=n643 B=n635 Y=product[29]
XU731 NAND2XL $PINS A=n775 B=n776 Y=n767
XU732 OAI211X2 $PINS A0=n808 A1=n597 B0=n953 C0=n954 Y=n939
XU733 OAI21XL $PINS A0=n937 A1=n939 B0=n938 Y=n951
XU734 AOI21XL $PINS A0=n600 A1=n602 B0=n955 Y=n964
XU735 OAI2BB1X1 $PINS A0N=n958 A1N=n959 B0=n960 Y=n938
XU736 OAI211X2 $PINS A0=n805 A1=n609 B0=n969 C0=n968 Y=n600
XU737 XOR2X1 $PINS A=_register_2_10 B=n779 Y=n759
XU738 OAI21XL $PINS A0=n959 A1=n958 B0=FE_OFN42_register_2__6 Y=n960
XU739 NOR2X1 $PINS A=a[1] B=a[3] Y=n612
XU740 OAI21XL $PINS A0=n849 A1=n850 B0=n851 Y=n848
XU741 AOI2BB2X2 $PINS A0N=n846 A1N=n872 B0=n870 B1=n871 Y=n850
XU743 NAND2X1 $PINS A=p6 B=n5214 Y=n958
XU744 OAI2BB1X1 $PINS A0N=n592 A1N=n863 B0=n851 Y=n862
XU745 INVX1 $PINS A=n661 Y=n891
XU747 AOI31X1 $PINS A0=n774 A1=n773 A2=n763 B0=n737 Y=n789
XU748 XNOR2XL $PINS A=n904 B=n560 Y=product[14]
XU749 XOR2X1 $PINS A=n763 B=n824 Y=product[18]
XU750 AOI31X1 $PINS A0=n718 A1=n628 A2=n692 B0=n633 Y=n557
XU751 OAI21XL $PINS A0=n902 A1=n901 B0=a[12] Y=n903
XU752 XNOR2X1 $PINS A=n938 B=n939 Y=n574
XU753 NAND2X2 $PINS A=n560 B=n843 Y=n869
XU754 OAI211X1 $PINS A0=n937 A1=n938 B0=n939 C0=n590 Y=n559
XU755 OAI2BB1X1 $PINS A0N=n880 A1N=n881 B0=n882 Y=n864
XU756 AND2X2 $PINS A=n905 B=n906 Y=n908
XU757 OAI222X2 $PINS A0=n905 A1=n906 B0=n907 B1=n908 C0=n559 C1=n909 Y=n560
XU758 OAI211X1 $PINS A0=n937 A1=n938 B0=n590 C0=n939 Y=n910
XU759 NAND2X1 $PINS A=n860 B=n603 Y=n602
XU760 XNOR2X1 $PINS A=p8 B=n806 Y=n781
XU761 AOI21X2 $PINS A0=a[15] A1=FE_OFN3_register_2__8 B0=n729 Y=n741
XU762 NOR2X1 $PINS A=FE_OFN3_register_2__8 B=a[15] Y=n729
XU764 AOI222X2 $PINS A0=n623 A1=n624 B0=n625 B1=n626 C0=n624 C1=n725 Y=n621
XU765 OAI22X1 $PINS A0=n897 A1=FE_OFN4_register_2__8
+ B0=FE_OFN5754_register_2__8 B1=n898 Y=n880
XU766 OAI21XL $PINS A0=n846 A1=n869 B0=n850 Y=n863
XU767 INVX1 $PINS A=n940 Y=n590
XU768 XOR2X1 $PINS A=a[2] B=n877 Y=n854
XU769 XOR2X1 $PINS A=p10 B=n779 Y=n855
XU770 AOI21X1 $PINS A0=n836 A1=n837 B0=n778 Y=n826
XU771 XNOR2X1 $PINS A=a[2] B=n615 Y=n613
XU772 AOI21X1 $PINS A0=n5214 A1=a[1] B0=p1 Y=n615
XU773 XNOR2X1 $PINS A=a[7] B=p12 Y=n779
XU777 AOI21X1 $PINS A0=n5214 A1=a[4] B0=n930 Y=n929
XU778 NOR2X2 $PINS A=n5214 B=a[4] Y=n930
XU779 XOR2X1 $PINS A=_register_2_10 B=n569 Y=n831
XU780 XNOR2X1 $PINS A=FE_OFN4_register_2__8 B=FE_OFN48_register_2__5 Y=n813
XU781 NOR2X1 $PINS A=p4 B=n5475 Y=n899
XU782 AOI211X2 $PINS A0=FE_OFN5664_n943 A1=n594 B0=n944 C0=n945 Y=n940
XU783 XOR2X1 $PINS A=n698 B=a[16] Y=n716
XU784 XNOR2XL $PINS A=n664 B=n891 Y=n675
XU785 NAND2XL $PINS A=n651 B=n652 Y=n636
XU786 XOR2X1 $PINS A=n822 B=n823 Y=n576
XU787 XNOR2XL $PINS A=n567 B=n695 Y=n693
XU788 XOR2XL $PINS A=n571 B=n863 Y=product[16]
XU789 NAND2BXL $PINS AN=n634 B=n636 Y=n643
XU790 NOR2X1 $PINS A=n694 B=n693 Y=n666
XU792 NOR2X1 $PINS A=n638 B=n637 Y=n627
XU794 XNOR2X1 $PINS A=a[18] B=a[16] Y=n568
XU795 AND2X1 $PINS A=n872 B=n869 Y=n572
XU796 NAND2BXL $PINS AN=n646 B=n650 Y=n665
XU797 INVX1 $PINS A=n666 Y=n570
XU798 XOR2XL $PINS A=n717 B=n557 Y=product[24]
XU799 XNOR2X1 $PINS A=n941 B=n566 Y=product[12]
XU800 OR2XL $PINS A=n589 B=n940 Y=n566
XU801 OAI211X2 $PINS A0=n956 A1=n957 B0=n602 C0=n600 Y=n953
XU802 INVX1 $PINS A=n956 Y=n808
XU803 INVXL $PINS A=n722 Y=n657
XU804 OAI2BB1X1 $PINS A0N=n784 A1N=n785 B0=n786 Y=n776
XU805 INVXL $PINS A=n656 Y=n710
XU806 INVXL $PINS A=n729 Y=n925
XU807 XOR2XL $PINS A=FE_OFN71_register_2__14 B=n716 Y=n700
XU808 XOR2X1 $PINS A=a[13] B=n568 Y=n662
XU809 OAI2BB1X2 $PINS A0N=n668 A1N=n570 B0=n667 Y=n644
XU810 NAND2XL $PINS A=n843 B=n872 Y=n904
XU811 NAND2BX1 $PINS AN=n666 B=n667 Y=n680
XU812 NAND2XL $PINS A=n658 B=n690 Y=n717
XU813 INVX1 $PINS A=n955 Y=n597
XU814 NOR2BXL $PINS AN=n773 B=n793 Y=n824
XU815 INVX1 $PINS A=n630 Y=n725
XU816 XOR2X1 $PINS A=n573 B=n885 Y=n871
XU817 XNOR2X1 $PINS A=n937 B=n574 Y=product[11]
XU818 XNOR2X1 $PINS A=n575 B=n933 Y=n945
XU819 XOR2X1 $PINS A=n934 B=n936 Y=n575
XU821 OAI211XL $PINS A0=n669 A1=n695 B0=n670 C0=n671 Y=n650
XU822 OAI21XL $PINS A0=_register_2_10 A1=n678 B0=n679 Y=n787
XU823 OAI21XL $PINS A0=a[16] A1=n746 B0=n703 Y=n755
XU824 OAI21XL $PINS A0=n646 A1=n645 B0=n648 Y=n647
XU825 OAI21XL $PINS A0=n645 A1=n648 B0=n650 Y=n649
XU826 OAI21XL $PINS A0=n757 A1=n796 B0=n797 Y=n795
XU827 INVXL $PINS A=n799 Y=n757
XU828 OAI2BB1X1 $PINS A0N=n607 A1N=n608 B0=n609 Y=n604
XU829 XNOR2X1 $PINS A=n675 B=n662 Y=n671
XU830 OAI21XL $PINS A0=n710 A1=n654 B0=n655 Y=n652
XU831 OAI2BB1XL $PINS A0N=n654 A1N=n710 B0=a[18] Y=n655
XU832 NAND2X1 $PINS A=n637 B=n638 Y=n630
XU833 XNOR2X1 $PINS A=n929 B=n838 Y=n961
XU834 AOI2BB1X1 $PINS A0N=n624 A1N=n623 B0=n627 Y=n626
XU835 OAI21XL $PINS A0=n838 A1=n946 B0=n929 Y=n948
XU836 OAI21XL $PINS A0=FE_OFN71_register_2__14 A1=n698 B0=n699 Y=n673
XU837 OAI21XL $PINS A0=n661 A1=n662 B0=n663 Y=n648
XU838 OAI2BB1X1 $PINS A0N=n662 A1N=n661 B0=n664 Y=n663
XU839 XOR2X1 $PINS A=n654 B=n577 Y=n645
XU840 XOR2X1 $PINS A=FE_OFN5869_register_2__18 B=n656 Y=n577
XU841 OAI21XL $PINS A0=n726 A1=n700 B0=n701 Y=n694
XU842 OAI2BB1X1 $PINS A0N=n700 A1N=n726 B0=n702 Y=n701
XU843 OAI21XL $PINS A0=FE_OFN71_register_2__14 A1=n732 B0=n891 Y=n709
XU844 OAI21XL $PINS A0=p6 A1=n5214 B0=n958 Y=n967
XU845 XNOR2X1 $PINS A=FE_OFN71_register_2__14 B=n624 Y=n654
XU846 XOR2X1 $PINS A=n616 B=n617 Y=product[4]
XU847 XNOR2XL $PINS A=n611 B=n828 Y=product[6]
XU848 XNOR2XL $PINS A=n612 B=n596 Y=n611
XU849 OAI21XL $PINS A0=n640 A1=n641 B0=n642 Y=n638
XU850 OAI2BB1X1 $PINS A0N=n641 A1N=n640 B0=p18 Y=n642
XU851 OAI21XL $PINS A0=a[16] A1=p11 B0=n659 Y=n656
XU852 OAI21XL $PINS A0=a[13] A1=p14 B0=FE_OFN312_register_2__18 Y=n659
XU853 NOR2X1 $PINS A=n652 B=n651 Y=n634
XU854 NOR2XL $PINS A=p13 B=FE_OFN5869_register_2__18 Y=n632
XU855 XOR2X1 $PINS A=n632 B=n639 Y=n637
XU856 XNOR2XL $PINS A=p18 B=a[16] Y=n639
XU857 OAI21XL $PINS A0=p12 A1=p10 B0=n858 Y=n839
XU858 OAI21XL $PINS A0=p15 A1=n732 B0=n891 Y=n749
XU859 OAI21XL $PINS A0=_register_2_10 A1=p11 B0=p15 Y=n715
XU860 XOR2X1 $PINS A=p10 B=n813 Y=n801
XU861 XOR2X1 $PINS A=n578 B=n713 Y=n707
XU862 XOR2XL $PINS A=n613 B=n614 Y=product[5]
XU863 NAND2XL $PINS A=p15 B=p18 Y=n620
XU865 XNOR2X1 $PINS A=n5214 B=p1 Y=n617
XU866 OAI21XL $PINS A0=FE_OFN48_register_2__5 A1=n5214 B0=n861 Y=n834
XU867 XNOR2X1 $PINS A=p1 B=FE_OFN48_register_2__5 Y=n965
XU868 XNOR2X1 $PINS A=a[15] B=p15 Y=n697
XU869 XNOR2X1 $PINS A=a[3] B=FE_OFN48_register_2__5 Y=n915
XU871 XNOR2X1 $PINS A=a[19] B=FE_OFN5869_register_2__18 Y=n619
XU872 OAI21XL $PINS A0=n632 A1=a[16] B0=a[19] Y=n631
XU873 XOR2X1 $PINS A=a[17] B=a[19] Y=n624
XU874 OAI21XL $PINS A0=p10 A1=FE_OFN48_register_2__5 B0=FE_OFN4_register_2__8
+ Y=n807
XU875 OAI21XL $PINS A0=n878 A1=FE_OFN4_register_2__8 B0=n879 Y=n857
XU876 OAI21XL $PINS A0=n886 A1=n885 B0=n888 Y=n887
XU878 OAI21XL $PINS A0=a[11] A1=a[4] B0=a[7] Y=n814
XU879 XNOR2X1 $PINS A=a[11] B=a[9] Y=n927
XU880 XOR2X1 $PINS A=a[15] B=FE_OFN5869_register_2__18 Y=n641
XU881 XOR2X1 $PINS A=FE_OFN5754_register_2__8 B=n614 Y=n959
XU882 XNOR2XL $PINS A=n665 B=n644 Y=product[27]
XU883 OAI2BB1X1 $PINS A0N=n939 A1N=n937 B0=n951 Y=n941
XU884 XNOR2XL $PINS A=n680 B=n668 Y=product[26]
XU473 XNOR2X1 $PINS A=a[11] B=n942 Y=n816
XU502 XOR2X1 $PINS A=a[7] B=a[4] Y=n942
XU524 XNOR2X1 $PINS A=a[14] B=n730 Y=n815
XU877 OAI2BB1X1 $PINS A0N=n950 A1N=n952 B0=n856 Y=n836
XU886 INVX1 $PINS A=n854 Y=n950
XU887 INVX1 $PINS A=n855 Y=n952
XU889 OAI21XL $PINS A0=n976 A1=n977 B0=n866 Y=n847
XU890 INVX1 $PINS A=n864 Y=n976
XU891 INVX1 $PINS A=n865 Y=n977
.ENDS

.SUBCKT CONV_DW_mult_uns_25 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[14] b[13]
+ b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0]
+ product[34] product[33] product[32] product[31] product[30] product[29]
+ product[28] product[27] product[26] product[25] product[24] product[23]
+ product[22] product[21] product[20] product[19] product[18] product[17]
+ product[16] product[15] product[14] product[13] product[12] product[11]
+ product[10] product[9] product[8] product[7] product[6] product[5] product[4]
+ product[3] product[2] product[1] product[0] n5107 p1 p2 p3 p4 p5 p6 p7 p8 p9
+ p10 p11 p12 p13 p14 p15 p16 p17 p18 _register_3_16 N611 _register_3_18 p19
+ p20 p21 p22
XFE_OCPC2321_n160 BUFX3 $PINS A=n160 Y=FE_OCPN6225_n160
XFE_OCPC2302_register_3__12 BUFX3 $PINS A=a[12] Y=FE_OCPN6206_register_3__12
XFE_OFC1828_n85 INVX1 $PINS A=n572 Y=FE_OFN5903_n85
XFE_OFC1827_n85 INVX1 $PINS A=n85 Y=n572
XFE_OFC1566_register_3__14 BUFX3 $PINS A=a[14] Y=FE_OFN5764_register_3__14
XFE_OFC1439_n252 INVX1 $PINS A=n554 Y=FE_OFN5695_n252
XFE_OFC1438_n252 CLKINVX3 $PINS A=n252 Y=n554
XFE_OFC283_n181 CLKINVX3 $PINS A=n181 Y=n558
XFE_OFC202_n26 INVX1 $PINS A=n26 Y=n604
XFE_OFC197_n397 INVX1 $PINS A=n397 Y=n605
XFE_OFC196_n22 INVX1 $PINS A=n22 Y=n607
XFE_DBTC183_n201 CLKINVX3 $PINS A=n201 Y=FE_DBTN183_n201
XU136 AOI21X4 $PINS A0=n153 A1=n134 B0=n135 Y=n133
XU237 OAI21X2 $PINS A0=n202 A1=n219 B0=n203 Y=n201
XU264 AOI21X2 $PINS A0=n239 A1=n220 B0=n221 Y=n219
XU439 NAND2X1 $PINS A=n525 B=n526 Y=product[27]
XU450 AND2X2 $PINS A=n554 B=n537 Y=n527
XU489 AOI21X1 $PINS A0=n583 A1=n210 B0=n603 Y=n203
XU496 AND2X2 $PINS A=n69 B=n566 Y=n532
XU564 NOR2X1 $PINS A=n404 B=n405 Y=n211
XU662 AOI21X2 $PINS A0=n172 A1=n163 B0=n164 Y=n162
XU667 OAI21X2 $PINS A0=FE_OFN5695_n252 A1=n240 B0=n241 Y=n239
XU485 XNOR2X1 $PINS A=n66 B=n6 Y=product[30]
XU488 AOI21X4 $PINS A0=FE_OCPN6225_n160 A1=n92 B0=n93 Y=n91
XU535 OAI21XL $PINS A0=n211 A1=n217 B0=n212 Y=n210
XU594 NAND2X1 $PINS A=n406 B=n407 Y=n217
XU599 NOR2X1 $PINS A=n351 B=n346 Y=n143
XU607 XNOR2X4 $PINS A=n120 B=n12 Y=product[24]
XU644 NOR2X1 $PINS A=n406 B=n407 Y=n216
XU440 NAND2X1 $PINS A=n382 B=n387 Y=n179
XU441 NAND2X1 $PINS A=n404 B=n405 Y=n212
XU442 XNOR2X2 $PINS A=n167 B=n542 Y=product[18]
XU444 NAND2X1 $PINS A=n537 B=n533 Y=n240
XU446 NOR2X1 $PINS A=n316 B=n321 Y=n98
XU447 ADDFX2 $PINS A=p21 B=n323 CI=n318 S=n316 CO=n315
XU448 ADDFX2 $PINS A=p22 B=n329 CI=n324 S=n322 CO=n321
XU451 ADDFX2 $PINS A=n392 B=n395 CI=n390 S=n388 CO=n387
XU452 NAND2BX1 $PINS AN=n70 B=n530 Y=n66
XU453 OAI21XL $PINS A0=n572 A1=n75 B0=n76 Y=n70
XU454 OAI21XL $PINS A0=FE_DBTN183_n201 A1=n187 B0=n188 Y=n186
XU455 OR2X2 $PINS A=n187 B=n184 Y=n548
XU456 NAND2X1 $PINS A=n535 B=n536 Y=n187
XU457 ADDFX2 $PINS A=a[10] B=n335 CI=n330 S=n328 CO=n327
XU458 ADDFX2 $PINS A=FE_OCPN6206_register_3__12 B=a[10] CI=n400 S=n398 CO=n397
XU460 NOR2BX1 $PINS AN=p5 B=n408 Y=n222
XU461 ADDHXL $PINS A=a[8] B=a[0] S=n408 CO=n407
XU462 NOR2X1 $PINS A=p1 B=a[2] Y=n257
XU465 NAND2X1 $PINS A=n370 B=n375 Y=n169
XU466 ADDFX2 $PINS A=p5 B=p7 CI=p15 S=n368 CO=n367
XU469 ADDFX2 $PINS A=p11 B=a[3] CI=n591 S=n402 CO=n401
XU471 ADDFX2 $PINS A=p10 B=a[2] CI=p3 S=n404 CO=n403
XU472 ADDFX2 $PINS A=p18 B=p11 CI=n367 S=n360 CO=n359
XU474 ADDFX2 $PINS A=_register_3_18 B=p11 CI=FE_OFN5764_register_3__14 S=n318
+ CO=n317
XU475 ADDFX2 $PINS A=a[15] B=N611 CI=n391 S=n384 CO=n383
XU479 NOR2X1 $PINS A=n225 B=n222 Y=n220
XU480 OAI21XL $PINS A0=n226 A1=n222 B0=n223 Y=n221
XU481 INVX1 $PINS A=n219 Y=n556
XU482 ADDFX2 $PINS A=p18 B=FE_OCPN6206_register_3__12 CI=a[15] S=n312 CO=n311
XU483 ADDFX2 $PINS A=n534 B=n342 CI=n347 S=n340 CO=n339
XU484 XOR2X2 $PINS A=n175 B=n20 Y=product[16]
XU486 OAI2BB1X2 $PINS A0N=n160 A1N=n574 B0=n158 Y=n156
XU487 XNOR2X2 $PINS A=n138 B=n14 Y=product[22]
XU490 OAI21XL $PINS A0=n86 A1=n90 B0=n87 Y=n85
XU492 NAND2X1 $PINS A=n116 B=n96 Y=n94
XU493 NOR2X1 $PINS A=n538 B=n178 Y=n171
XU494 NOR2X1 $PINS A=n358 B=n363 Y=n157
XU495 NAND2BX1 $PINS AN=n236 B=n237 Y=n30
XU497 NAND2BXL $PINS AN=n143 B=n144 Y=n15
XU498 AOI2BB1X4 $PINS A0N=n548 A1N=FE_DBTN183_n201 B0=n183 Y=n181
XU499 XNOR2X1 $PINS A=n109 B=n11 Y=product[25]
XU500 NOR2X1 $PINS A=n402 B=n403 Y=n206
XU501 XNOR2X2 $PINS A=n156 B=n16 Y=product[20]
XU502 NAND2X1 $PINS A=n568 B=n103 Y=n101
XU503 AOI2BB1X2 $PINS A0N=n255 A1N=n257 B0=n561 Y=n252
XU504 NAND2X1 $PINS A=n559 B=n9 Y=n526
XU505 OAI21X2 $PINS A0=n560 A1=n121 B0=n122 Y=n120
XU506 INVX4 $PINS A=n160 Y=n560
XU507 NAND2X1 $PINS A=n364 B=n369 Y=n166
XU508 XOR2X1 $PINS A=n246 B=n31 Y=product[5]
XU509 NAND2X1 $PINS A=n568 B=n116 Y=n110
XU510 INVX1 $PINS A=n132 Y=n568
XU511 OAI2BB1X1 $PINS A0N=n532 A1N=n559 B0=n61 Y=n59
XU512 INVX1 $PINS A=n91 Y=n559
XU513 NAND2X1 $PINS A=n583 B=n209 Y=n202
XU514 INVX1 $PINS A=n206 Y=n583
XU515 XNOR3X2 $PINS A=n170 B=n370 C=n375 Y=product[17]
XU516 AOI21X1 $PINS A0=n567 A1=n103 B0=n104 Y=n102
XU517 INVX1 $PINS A=n133 Y=n567
XU518 XNOR2X1 $PINS A=n160 B=n17 Y=product[19]
XU519 AOI21X4 $PINS A0=n558 A1=n171 B0=n172 Y=n170
XU522 NAND2BX1 $PINS AN=n255 B=n256 Y=n33
XU524 NAND2X1 $PINS A=n322 B=n327 Y=n108
XU525 NAND2X1 $PINS A=n569 B=n152 Y=n139
XU526 INVXL $PINS A=n143 Y=n569
XU527 AOI2BB1X2 $PINS A0N=n199 A1N=n550 B0=n602 Y=n188
XU529 NOR2X1 $PINS A=n370 B=n375 Y=n168
XU530 AOI22XL $PINS A0=n351 A1=n346 B0=n569 B1=n153 Y=n140
XU531 OR2X2 $PINS A=n132 B=n125 Y=n121
XU532 NOR2X1 $PINS A=n107 B=n98 Y=n96
XU533 NOR2X1 $PINS A=n168 B=n165 Y=n163
XU536 NOR2X1 $PINS A=n527 B=n587 Y=n246
XU538 ADDFX2 $PINS A=_register_3_16 B=a[17] CI=a[18] S=n298 CO=n297
XU539 NAND2BXL $PINS AN=n154 B=n155 Y=n16
XU540 NAND2X1 $PINS A=n357 B=n352 Y=n155
XU541 XNOR2X1 $PINS A=n239 B=n30 Y=product[6]
XU542 NAND2X1 $PINS A=p8 B=a[5] Y=n245
XU543 OAI21XL $PINS A0=n91 A1=n571 B0=n572 Y=n77
XU544 ADDFX2 $PINS A=_register_3_16 B=a[8] CI=n385 S=n378 CO=n377
XU545 ADDFX2 $PINS A=_register_3_16 B=a[9] CI=FE_OCPN6206_register_3__12 S=n330
+ CO=n329
XU547 ADDFX2 $PINS A=a[15] B=FE_OFN5764_register_3__14 CI=p11 S=n336 CO=n335
XU548 ADDFX2 $PINS A=a[13] B=a[19] CI=n350 S=n348 CO=n347
XU549 XOR2X1 $PINS A=p5 B=a[8] Y=n356
XU550 ADDFX2 $PINS A=FE_OFN5764_register_3__14 B=p5 CI=p21 S=n390 CO=n389
XU551 NAND2X1 $PINS A=a[4] B=p5 Y=n237
XU552 NOR2X1 $PINS A=a[4] B=p5 Y=n236
XU553 NAND2X1 $PINS A=n163 B=n171 Y=n161
XU554 OAI21XL $PINS A0=n118 A1=n126 B0=n119 Y=n117
XU555 ADDFX2 $PINS A=n362 B=n365 CI=n360 S=n358 CO=n357
XU557 AOI2BB1X1 $PINS A0N=n229 A1N=n237 B0=n597 Y=n226
XU558 NAND2X1 $PINS A=n408 B=a[6] Y=n223
XU560 ADDFX2 $PINS A=n361 B=n354 CI=n359 S=n352 CO=n351
XU561 NAND2X1 $PINS A=n388 B=n393 Y=n185
XU562 OAI21XL $PINS A0=n538 A1=n179 B0=n174 Y=n172
XU563 ADDFX2 $PINS A=n389 B=n386 CI=n384 S=n382 CO=n381
XU565 NAND2X1 $PINS A=n358 B=n363 Y=n158
XU566 NAND2X1 $PINS A=n334 B=n339 Y=n126
XU567 ADDFX2 $PINS A=n591 B=n341 CI=n336 S=n334 CO=n333
XU568 AOI21X1 $PINS A0=n556 A1=n209 B0=n210 Y=n208
XU569 XNOR2X1 $PINS A=n193 B=n23 Y=product[13]
XU570 XNOR2X1 $PINS A=n77 B=n7 Y=product[29]
XU571 XNOR2X2 $PINS A=n88 B=n8 Y=product[28]
XU572 NAND2X2 $PINS A=n152 B=n134 Y=n132
XU573 NOR2X1 $PINS A=n125 B=n118 Y=n116
XU574 OAI21XL $PINS A0=n91 A1=n49 B0=n50 Y=n48
XU575 XNOR2X1 $PINS A=n59 B=n5 Y=product[31]
XU576 NAND2X1 $PINS A=n398 B=n401 Y=n199
XU577 AOI2BB2X4 $PINS A0N=n181 A1N=n178 B0=n382 B1=n387 Y=n175
XU578 ADDFX2 $PINS A=n380 B=n383 CI=n378 S=n376 CO=n375
XU579 OAI21X2 $PINS A0=n188 A1=n184 B0=n185 Y=n183
XU580 NOR2X1 $PINS A=n211 B=n216 Y=n209
XU581 OAI21XL $PINS A0=n133 A1=n94 B0=n95 Y=n93
XU584 INVX1 $PINS A=n535 Y=n550
XU585 NOR2X1 $PINS A=n143 B=n136 Y=n134
XU587 NOR2X1 $PINS A=n322 B=n327 Y=n107
XU588 NOR2X1 $PINS A=n334 B=n339 Y=n125
XU589 NOR2X1 $PINS A=n328 B=n333 Y=n118
XU590 XNOR2X1 $PINS A=n48 B=n4 Y=product[32]
XU591 OAI21XL $PINS A0=n91 A1=n42 B0=n43 Y=n41
XU592 OAI21XL $PINS A0=n136 A1=n144 B0=n137 Y=n135
XU593 AOI21X1 $PINS A0=n96 A1=n117 B0=n97 Y=n95
XU595 OAI21XL $PINS A0=n98 A1=n108 B0=n99 Y=n97
XU596 OR2X2 $PINS A=p9 B=p7 Y=n537
XU598 ADDFX2 $PINS A=N611 B=a[5] CI=p20 S=n362 CO=n361
XU600 ADDFX2 $PINS A=n368 B=n371 CI=n366 S=n364 CO=n363
XU601 ADDFX2 $PINS A=a[13] B=n399 CI=n396 S=n394 CO=n393
XU602 OR2X2 $PINS A=n236 B=n229 Y=n225
XU603 INVX1 $PINS A=n230 Y=n597
XU605 NAND2X1 $PINS A=n376 B=n381 Y=n174
XU608 NOR2X1 $PINS A=n382 B=n387 Y=n178
XU609 XOR2X1 $PINS A=n208 B=n25 Y=product[11]
XU610 XOR2X1 $PINS A=n33 B=n257 Y=product[3]
XU611 OAI21XL $PINS A0=n219 A1=n216 B0=n217 Y=n528
XU612 XOR2X1 $PINS A=n556 B=n544 Y=product[9]
XU613 ADDFX2 $PINS A=n5107 B=n317 CI=n312 S=n310 CO=n309
XU614 INVX1 $PINS A=n75 Y=n575
XU616 XNOR2X2 $PINS A=n558 B=n21 Y=product[15]
XU617 NAND2BX1 $PINS AN=n178 B=n179 Y=n21
XU618 NOR2X1 $PINS A=n571 B=n75 Y=n69
XU619 XOR2X1 $PINS A=n529 B=n15 Y=product[21]
XU620 AOI21X1 $PINS A0=n567 A1=n579 B0=n580 Y=n122
XU621 NAND2X1 $PINS A=n310 B=n315 Y=n90
XU622 ADDFX2 $PINS A=a[15] B=p20 CI=n307 S=n302 CO=n301
XU623 NOR2X1 $PINS A=n310 B=n315 Y=n89
XU624 NOR2X1 $PINS A=n306 B=n309 Y=n86
XU625 NOR2X1 $PINS A=n340 B=n345 Y=n136
XU626 NOR2X1 $PINS A=n89 B=n86 Y=n84
XU627 NOR2X1 $PINS A=n132 B=n94 Y=n92
XU628 NOR2BX1 $PINS AN=n217 B=n216 Y=n544
XU629 OAI21XL $PINS A0=n555 A1=n225 B0=n226 Y=n224
XU630 NAND2X1 $PINS A=p6 B=N611 Y=n230
XU631 NOR2X1 $PINS A=p6 B=N611 Y=n229
XU632 OAI21XL $PINS A0=n555 A1=n236 B0=n237 Y=n231
XU633 NAND2BX1 $PINS AN=a[2] B=p7 Y=n250
XU634 OAI21X2 $PINS A0=n560 A1=n139 B0=n140 Y=n138
XU635 ADDFX2 $PINS A=n355 B=n353 CI=n348 S=n346 CO=n345
XU636 XNOR2X2 $PINS A=n127 B=n13 Y=product[23]
XU637 OAI21X1 $PINS A0=n560 A1=n132 B0=n133 Y=n127
XU638 NOR2BX1 $PINS AN=n223 B=n222 Y=n543
XU639 AOI21X1 $PINS A0=n567 A1=n116 B0=n117 Y=n111
XU640 INVX1 $PINS A=n239 Y=n555
XU641 AOI21X1 $PINS A0=n160 A1=n152 B0=n153 Y=n529
XU642 XNOR2X1 $PINS A=p1 B=a[2] Y=product[2]
XU643 OAI21X4 $PINS A0=n161 A1=n181 B0=n162 Y=n160
XU645 CMPR32X1 $PINS A=a[17] B=p10 C=a[13] S=n324 CO=n323
XU646 ADDFX2 $PINS A=a[17] B=_register_3_18 CI=a[19] S=n294 CO=n293
XU647 OAI21XL $PINS A0=n91 A1=n89 B0=n90 Y=n88
XU648 NOR2XL $PINS A=n291 B=a[19] Y=n39
XU649 NAND2X1 $PINS A=p2 B=a[3] Y=n256
XU650 NAND2X1 $PINS A=n91 B=n573 Y=n525
XU651 NAND2BX1 $PINS AN=n91 B=n69 Y=n530
XU652 OAI21XL $PINS A0=n560 A1=n110 B0=n111 Y=n109
XU653 OAI21XL $PINS A0=n165 A1=n169 B0=n166 Y=n164
XU654 XNOR2X1 $PINS A=n100 B=n10 Y=product[26]
XU655 OAI21XL $PINS A0=n560 A1=n101 B0=n102 Y=n100
XU656 NOR2X1 $PINS A=n157 B=n154 Y=n152
XU657 NOR2X1 $PINS A=p2 B=a[3] Y=n255
XU658 XOR2X1 $PINS A=n224 B=n543 Y=product[8]
XU659 OAI21X2 $PINS A0=n154 A1=n158 B0=n155 Y=n153
XU661 XOR2XL $PINS A=N611 B=a[9] Y=n350
XU663 NAND2XL $PINS A=n328 B=n333 Y=n119
XU664 NOR2X2 $PINS A=n388 B=n393 Y=n184
XU665 NAND2XL $PINS A=n533 B=n245 Y=n31
XU666 INVX1 $PINS A=n250 Y=n587
XU668 NAND2XL $PINS A=n536 B=n199 Y=n552
XU669 XOR2X1 $PINS A=n554 B=n553 Y=product[4]
XU670 NAND2BXL $PINS AN=n89 B=n90 Y=n9
XU671 AND2X2 $PINS A=n537 B=n250 Y=n553
XU672 NAND2BX1 $PINS AN=n538 B=n174 Y=n20
XU673 NAND2X1 $PINS A=n316 B=n321 Y=n99
XU674 NAND2BXL $PINS AN=n165 B=n166 Y=n542
XU675 NAND2XL $PINS A=n575 B=n76 Y=n7
XU676 AOI21XL $PINS A0=FE_OFN5903_n85 A1=n565 B0=n564 Y=n50
XU677 NAND2X1 $PINS A=n340 B=n345 Y=n137
XU678 INVX1 $PINS A=a[9] Y=n591
XU679 ADDFX2 $PINS A=FE_OCPN6206_register_3__12 B=a[18] CI=n356 S=n354 CO=n353
XU681 XOR2X1 $PINS A=FE_DBTN183_n201 B=n552 Y=product[12]
XU682 NOR2X1 $PINS A=n364 B=n369 Y=n165
XU683 NOR2X1 $PINS A=n357 B=n352 Y=n154
XU684 NAND2BXL $PINS AN=n57 B=n58 Y=n5
XU685 INVXL $PINS A=n64 Y=n566
XU686 INVXL $PINS A=n125 Y=n579
XU687 NOR2XL $PINS A=n53 B=n46 Y=n44
XU688 INVX1 $PINS A=n245 Y=n588
XU689 AOI21X1 $PINS A0=n587 A1=n533 B0=n588 Y=n241
XU690 NAND2BXL $PINS AN=n229 B=n230 Y=n29
XU691 NAND2XL $PINS A=n306 B=n309 Y=n87
XU692 NAND2XL $PINS A=n293 B=n292 Y=n47
XU694 INVX1 $PINS A=n9 Y=n573
XU695 INVX1 $PINS A=n53 Y=n565
XU696 NAND2BX1 $PINS AN=n157 B=n158 Y=n17
XU697 NAND2BXL $PINS AN=n118 B=n119 Y=n12
XU698 INVX1 $PINS A=n157 Y=n574
XU699 NOR2BX1 $PINS AN=n116 B=n107 Y=n103
XU700 OAI21XL $PINS A0=n578 A1=n107 B0=n108 Y=n104
XU701 INVXL $PINS A=n117 Y=n578
XU702 NAND2X1 $PINS A=n575 B=n55 Y=n53
XU703 NAND2X1 $PINS A=n44 B=n84 Y=n42
XU704 INVX1 $PINS A=n84 Y=n571
XU705 NAND2BXL $PINS AN=n107 B=n108 Y=n11
XU706 NAND2BXL $PINS AN=n98 B=n99 Y=n10
XU707 NOR2X1 $PINS A=n376 B=n381 Y=n538
XU708 NAND2BX1 $PINS AN=n184 B=n185 Y=n22
XU709 INVXL $PINS A=n126 Y=n580
XU710 NAND2XL $PINS A=n579 B=n126 Y=n13
XU711 NAND2BX1 $PINS AN=n86 B=n87 Y=n8
XU712 NAND2BXL $PINS AN=n136 B=n137 Y=n14
XU713 NAND2BXL $PINS AN=n206 B=n207 Y=n25
XU714 NAND2XL $PINS A=n535 B=n192 Y=n23
XU715 OAI2BB1X1 $PINS A0N=n201 A1N=n536 B0=n199 Y=n193
XU716 NAND2BX1 $PINS AN=n211 B=n212 Y=n26
XU717 AOI21XL $PINS A0=n44 A1=FE_OFN5903_n85 B0=n45 Y=n43
XU718 OAI21XL $PINS A0=n54 A1=n46 B0=n47 Y=n45
XU719 NOR2X1 $PINS A=n64 B=n57 Y=n55
XU720 INVX1 $PINS A=n54 Y=n564
XU721 NAND2BX1 $PINS AN=n46 B=n47 Y=n4
XU722 NAND2XL $PINS A=n84 B=n565 Y=n49
XU723 NAND2X1 $PINS A=n566 B=n65 Y=n6
XU724 ADDFX2 $PINS A=n374 B=n377 CI=n372 S=n370 CO=n369
XU725 NAND2X1 $PINS A=n351 B=n346 Y=n144
XU726 XNOR2X1 $PINS A=n231 B=n29 Y=product[7]
XU727 OR2X2 $PINS A=n398 B=n401 Y=n536
XU728 AOI31X1 $PINS A0=n55 A1=n302 A2=n305 B0=n56 Y=n54
XU729 OAI21XL $PINS A0=n57 A1=n65 B0=n58 Y=n56
XU730 NOR2X1 $PINS A=n294 B=n297 Y=n57
XU731 INVX1 $PINS A=n256 Y=n561
XU732 NOR2X1 $PINS A=n301 B=n298 Y=n64
XU733 AOI22X1 $PINS A0=n301 A1=n298 B0=n566 B1=n70 Y=n61
XU734 OR2X2 $PINS A=p8 B=a[5] Y=n533
XU735 NAND2X1 $PINS A=n301 B=n298 Y=n65
XU736 NAND2X1 $PINS A=n294 B=n297 Y=n58
XU737 XOR3X2 $PINS A=n41 B=n291 C=a[19] Y=product[33]
XU739 NOR2X1 $PINS A=n305 B=n302 Y=n75
XU740 NOR2X1 $PINS A=n293 B=n292 Y=n46
XU741 AOI2BB2X1 $PINS A0N=n43 A1N=n39 B0=n291 B1=a[19] Y=n36
XU742 NAND2X1 $PINS A=n305 B=n302 Y=n76
XU744 ADDFX2 $PINS A=a[5] B=a[3] CI=p14 S=n374 CO=n373
XU745 ADDFX2 $PINS A=a[17] B=a[9] CI=n379 S=n372 CO=n371
XU746 ADDFX2 $PINS A=_register_3_18 B=p10 CI=n373 S=n366 CO=n365
XU748 ADDFX2 $PINS A=a[13] B=n308 CI=n311 S=n306 CO=n305
XU749 XNOR2X1 $PINS A=FE_OFN5764_register_3__14 B=_register_3_16 Y=n308
XU750 ADDFX2 $PINS A=p10 B=a[8] CI=p19 S=n342 CO=n341
XU751 ADDFX2 $PINS A=a[5] B=a[1] CI=p22 S=n396 CO=n395
XU752 OR2XL $PINS A=FE_OFN5764_register_3__14 B=_register_3_16 Y=n307
XU753 XNOR2XL $PINS A=p18 B=_register_3_18 Y=n292
XU754 XNOR2XL $PINS A=n34 B=p18 Y=product[34]
XU755 OAI21XL $PINS A0=n91 A1=n545 B0=n36 Y=n34
XU756 OR2X2 $PINS A=n42 B=n39 Y=n545
XU757 OR2XL $PINS A=p18 B=_register_3_18 Y=n291
XU758 AND2X1 $PINS A=N611 B=a[9] Y=n534
XU759 ADDFX2 $PINS A=a[9] B=a[1] CI=a[7] S=n406 CO=n405
XU760 AND2X1 $PINS A=p5 B=a[8] Y=n355
XU761 ADDHXL $PINS A=p7 B=a[0] S=n400 CO=n399
XU762 ADDFX2 $PINS A=p7 B=a[2] CI=p19 S=n380 CO=n379
XU763 ADDHXL $PINS A=a[2] B=a[0] S=n392 CO=n391
XU764 ADDFX2 $PINS A=a[3] B=a[1] CI=n5107 S=n386 CO=n385
XU443 AND2X2 $PINS A=n394 B=n397 Y=n602
XU476 INVX1 $PINS A=n602 Y=n192
XU477 AND2X2 $PINS A=n402 B=n403 Y=n603
XU478 INVX1 $PINS A=n603 Y=n207
XU521 XOR2X1 $PINS A=n528 B=n604 Y=product[10]
XU528 NAND2BX2 $PINS AN=n394 B=n605 Y=n535
XU765 OR2X2 $PINS A=n170 B=n168 Y=n606
XU766 NAND2X1 $PINS A=n606 B=n169 Y=n167
XU767 XOR2X1 $PINS A=n186 B=n607 Y=product[14]
.ENDS

.SUBCKT CONV_DW_mult_uns_24 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[15] b[14]
+ b[13] b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0]
+ product[35] product[34] product[33] product[32] product[31] product[30]
+ product[29] product[28] product[27] product[26] product[25] product[24]
+ product[23] product[22] product[21] product[20] product[19] product[18]
+ product[17] product[16] product[15] product[14] product[13] product[12]
+ product[11] product[10] product[9] product[8] product[7] product[6]
+ product[5] product[4] product[3] product[2] product[1] product[0] n5104 n4988
+ FE_OFN49_register_1__4 FE_OFN56_register_1__13 FE_OFN94_register_1__6
*.CONNECT FE_RN_1 a[1]
*.CONNECT product[35] n33
XFE_OCPC2312_n192 CLKBUFX3 $PINS A=n192 Y=FE_OCPN6216_n192
XFE_OFC1826_n100 INVXL $PINS A=n100 Y=FE_OFN5902_n100
XFE_OFC1778_n164 INVXL $PINS A=n164 Y=n694
XFE_OFC920_n192 INVX4 $PINS A=n192 Y=n711
XU131 XNOR2X2 $PINS A=n141 B=n11 Y=product[23]
XU143 XNOR2X4 $PINS A=n152 B=n12 Y=product[22]
XU155 NOR2X2 $PINS A=n350 B=n341 Y=n150
XU174 AOI21X2 $PINS A0=n166 A1=n185 B0=n167 Y=n165
XU175 NOR2X1 $PINS A=n175 B=n168 Y=n166
XU211 XNOR2X4 $PINS A=n199 B=n18 Y=product[16]
XU220 NOR2X2 $PINS A=n411 B=n422 Y=n197
XU226 NOR2X2 $PINS A=n423 B=n434 Y=n200
XU244 XNOR2X1 $PINS A=n218 B=n22 Y=product[12]
XU234 NOR2X2 $PINS A=n435 B=n444 Y=n205
XU228 XOR2X2 $PINS A=n207 B=n20 Y=product[14]
XU213 OAI21X4 $PINS A0=n193 A1=n213 B0=n194 Y=n192
XU261 OAI21X4 $PINS A0=n223 A1=n235 B0=n224 Y=n222
XU246 AOI21X4 $PINS A0=n222 A1=n214 B0=n215 Y=n213
XU479 NAND2X1 $PINS A=n702 B=n708 Y=n101
XU482 ADDFHX2 $PINS A=n439 B=n446 CI=n437 S=n435 CO=n434
XU490 XNOR2X2 $PINS A=n116 B=n8 Y=product[26]
XU530 NOR2X2 $PINS A=n351 B=n362 Y=n157
XU697 ADDFX2 $PINS A=n441 B=n443 CI=n448 S=n437 CO=n436
XU714 AND2X2 $PINS A=a[11] B=a[8] Y=n634
XU723 AND2X2 $PINS A=n135 B=n694 Y=n639
XU735 NAND2X2 $PINS A=n184 B=n166 Y=n164
XU680 OAI21X1 $PINS A0=n101 A1=n122 B0=n102 Y=n100
XU459 OAI21XL $PINS A0=n123 A1=n121 B0=n122 Y=n116
XU460 OR2X2 $PINS A=n205 B=n211 Y=n652
XU461 NAND2X2 $PINS A=n652 B=n206 Y=n204
XU462 NAND2X1 $PINS A=n435 B=n444 Y=n206
XU464 XOR2X1 $PINS A=a[10] B=a[15] Y=n653
XU465 XOR2X1 $PINS A=a[17] B=n653 Y=n407
XU466 NAND2XL $PINS A=a[10] B=a[17] Y=n654
XU467 NAND2XL $PINS A=a[15] B=a[17] Y=n655
XU468 NAND2XL $PINS A=a[15] B=a[10] Y=n656
XU469 NAND3X1 $PINS A=n656 B=n654 C=n655 Y=n406
XU471 ADDFX2 $PINS A=n407 B=n405 CI=n414 S=n401 CO=n400
XU472 ADDFX2 $PINS A=n430 B=n421 CI=n417 S=n415 CO=n414
XU473 XNOR2X1 $PINS A=n715 B=n21 Y=product[13]
XU474 NAND3X1 $PINS A=n622 B=n620 C=n621 Y=n398
XU475 NAND2X1 $PINS A=n401 B=n412 Y=n620
XU476 NAND2X1 $PINS A=n403 B=n401 Y=n622
XU477 XOR2X2 $PINS A=n711 B=n17 Y=product[17]
XU478 XNOR2X2 $PINS A=n159 B=n13 Y=product[21]
XU480 XNOR2X2 $PINS A=n132 B=n10 Y=product[24]
XU481 AOI21X1 $PINS A0=n693 A1=n148 B0=n149 Y=n143
XU483 NOR2X1 $PINS A=n375 B=n386 Y=n175
XU484 ADDFX2 $PINS A=n379 B=n388 CI=n377 S=n375 CO=n374
XU485 INVX1 $PINS A=n165 Y=n693
XU486 ADDFX2 $PINS A=n418 B=n409 CI=n416 S=n403 CO=n402
XU487 INVX2 $PINS A=n213 Y=n715
XU488 ADDFHX1 $PINS A=n344 B=n342 CI=n333 S=n331 CO=n330
XU489 OR2X2 $PINS A=n363 B=n374 Y=n666
XU491 ADDFHX1 $PINS A=n476 B=n474 CI=n467 S=n465 CO=n464
XU492 ADDHXL $PINS A=FE_RN_1 B=a[0] S=n499 CO=n498
XU494 ADDFX2 $PINS A=a[5] B=FE_RN_1 CI=a[3] S=n505 CO=n504
XU495 NAND2X1 $PINS A=n465 B=n472 Y=n220
XU496 ADDFX2 $PINS A=n313 B=n311 CI=n316 S=n309 CO=n308
XU497 NAND2X1 $PINS A=n357 B=n355 Y=n663
XU498 NAND2X1 $PINS A=n351 B=n362 Y=n158
XU500 XNOR2X1 $PINS A=n719 B=n649 Y=product[7]
XU501 NOR2X1 $PINS A=n322 B=n315 Y=n121
XU502 INVX1 $PINS A=n105 Y=n708
XU504 NOR2X2 $PINS A=n164 B=n126 Y=n124
XU505 XOR3X2 $PINS A=n298 B=n297 C=n76 Y=product[30]
XU506 AOI2BB1X1 $PINS A0N=n123 A1N=n86 B0=n643 Y=n681
XU507 NOR2X2 $PINS A=n205 B=n210 Y=n203
XU508 NAND2XL $PINS A=n704 B=n702 Y=n108
XU509 OAI2BB2X2 $PINS A0N=n387 A1N=n398 B0=n186 B1=n190 Y=n185
XU510 NAND2X1 $PINS A=n696 B=n184 Y=n171
XU511 INVX1 $PINS A=n175 Y=n696
XU512 XOR2X1 $PINS A=n9 B=n123 Y=product[25]
XU513 NAND2BX1 $PINS AN=n219 B=n220 Y=n23
XU514 XOR2X1 $PINS A=n718 B=n648 Y=product[9]
XU515 NOR2X1 $PINS A=n308 B=n305 Y=n105
XU516 NAND2BXL $PINS AN=n157 B=n158 Y=n13
XU517 XOR3X2 $PINS A=n252 B=n506 C=n505 Y=product[5]
XU518 AOI2BB1X1 $PINS A0N=n213 A1N=n210 B0=n714 Y=n207
XU519 AOI31X1 $PINS A0=n702 A1=n322 A2=n315 B0=n703 Y=n109
XU520 INVX1 $PINS A=n114 Y=n702
XU521 XNOR2X1 $PINS A=n67 B=n3 Y=product[31]
XU522 NAND2X1 $PINS A=n423 B=n434 Y=n201
XU523 OAI2BB1X1 $PINS A0N=n192 A1N=n184 B0=n697 Y=n177
XU524 OAI21XL $PINS A0=n123 A1=n108 B0=n109 Y=n107
XU525 NAND2BXL $PINS AN=n210 B=n211 Y=n21
XU526 OAI21X1 $PINS A0=n126 A1=n165 B0=n127 Y=n125
XU527 XNOR2X1 $PINS A=n435 B=n444 Y=n20
XU528 AOI21X1 $PINS A0=n718 A1=n629 B0=n717 Y=n229
XU529 AOI21X1 $PINS A0=n715 A1=n203 B0=n204 Y=n202
XU531 NOR2X1 $PINS A=n363 B=n374 Y=n168
XU532 OAI2BB1X1 $PINS A0N=n661 A1N=FE_OCPN6216_n192 B0=n143 Y=n141
XU534 NOR2BX1 $PINS AN=n106 B=n105 Y=n709
XU535 OAI21X1 $PINS A0=n197 A1=n201 B0=n198 Y=n196
XU536 OAI2BB1X1 $PINS A0N=n716 A1N=n222 B0=n220 Y=n218
XU537 INVX1 $PINS A=n115 Y=n703
XU538 OAI2BB1X1 $PINS A0N=n666 A1N=n695 B0=n169 Y=n167
XU539 OAI2BB1X1 $PINS A0N=n679 A1N=n192 B0=n154 Y=n152
XU540 NAND2X1 $PINS A=n368 B=n355 Y=n664
XU541 OAI21XL $PINS A0=n78 A1=n74 B0=n75 Y=n71
XU542 NAND2BX1 $PINS AN=n200 B=n201 Y=n19
XU543 AOI2BB1X2 $PINS A0N=n175 A1N=n697 B0=n695 Y=n172
XU544 INVX1 $PINS A=n185 Y=n697
XU545 INVX1 $PINS A=n176 Y=n695
XU546 NOR2X1 $PINS A=n330 B=n323 Y=n130
XU547 AOI2BB2X1 $PINS A0N=n165 A1N=n157 B0=n351 B1=n362 Y=n154
XU548 INVX1 $PINS A=n235 Y=n718
XU549 ADDFX2 $PINS A=a[7] B=a[4] CI=a[10] S=n385 CO=n384
XU550 ADDFHX1 $PINS A=n468 B=n466 CI=n457 S=n455 CO=n454
XU551 ADDFX2 $PINS A=a[4] B=FE_RN_1 CI=a[6] S=n453 CO=n452
XU552 OAI21X2 $PINS A0=n711 A1=n171 B0=n172 Y=n170
XU553 NAND2X1 $PINS A=n411 B=n422 Y=n198
XU554 CLKINVX3 $PINS A=n244 Y=n719
XU557 NAND2BX1 $PINS AN=n197 B=n198 Y=n18
XU558 ADDFX2 $PINS A=a[14] B=a[19] CI=a[17] S=n359 CO=n358
XU559 ADDFX2 $PINS A=a[14] B=a[12] CI=n462 S=n417 CO=n416
XU560 ADDFX2 $PINS A=a[13] B=a[11] CI=n420 S=n405 CO=n404
XU561 ADDFHX2 $PINS A=n478 B=n469 CI=n471 S=n467 CO=n466
XU562 ADDFX2 $PINS A=a[11] B=a[7] CI=a[9] S=n469 CO=n468
XU563 XNOR2X2 $PINS A=n188 B=n16 Y=product[18]
XU564 AOI21X2 $PINS A0=n195 A1=n204 B0=n196 Y=n194
XU565 XOR3X2 $PINS A=a[9] B=a[10] C=a[16] Y=n419
XU566 NAND2XL $PINS A=a[16] B=a[9] Y=n657
XU567 NAND2XL $PINS A=a[10] B=a[9] Y=n658
XU568 NAND2XL $PINS A=a[10] B=a[16] Y=n659
XU569 NAND3X1 $PINS A=n659 B=n657 C=n658 Y=n418
XU571 OAI21XL $PINS A0=n130 A1=n140 B0=n131 Y=n129
XU572 NOR2X1 $PINS A=n139 B=n130 Y=n128
XU573 NAND2X1 $PINS A=n375 B=n386 Y=n176
XU575 NOR2X1 $PINS A=n387 B=n398 Y=n186
XU576 ADDFHX2 $PINS A=n391 B=n400 CI=n389 S=n387 CO=n386
XU577 XNOR2X2 $PINS A=n92 B=n6 Y=product[28]
XU578 NOR2X1 $PINS A=n340 B=n331 Y=n139
XU579 ADDFHX1 $PINS A=n345 B=n352 CI=n343 S=n341 CO=n340
XU580 NAND2X1 $PINS A=n99 B=n81 Y=n77
XU583 NOR2X1 $PINS A=n507 B=a[0] Y=n253
XU584 ADDFX2 $PINS A=a[15] B=a[12] CI=n361 S=n357 CO=n356
XU585 NAND2X1 $PINS A=n70 B=n712 Y=n61
XU586 ADDFX2 $PINS A=n463 B=n442 CI=n440 S=n427 CO=n426
XU587 ADDFX2 $PINS A=a[4] B=FE_RN_1 CI=a[7] S=n421 CO=n420
XU588 ADDFX2 $PINS A=a[6] B=a[3] CI=a[9] S=n397 CO=n396
XU589 ADDFX2 $PINS A=n429 B=n431 CI=n438 S=n425 CO=n424
XU590 ADDFX2 $PINS A=n451 B=n453 CI=n458 S=n447 CO=n446
XU591 ADDFHX1 $PINS A=a[12] B=n452 CI=n450 S=n439 CO=n438
XU592 ADDFHX1 $PINS A=n470 B=n461 CI=n459 S=n457 CO=n456
XU594 ADDFX2 $PINS A=a[3] B=FE_RN_1 CI=a[4] S=n479 CO=n478
XU595 ADDFX2 $PINS A=n428 B=n419 CI=n426 S=n413 CO=n412
XU596 ADDFX2 $PINS A=n406 B=n397 CI=n395 S=n391 CO=n390
XU597 NOR2X1 $PINS A=n304 B=n301 Y=n90
XU598 OR2X2 $PINS A=n505 B=n506 Y=n632
XU599 ADDFX2 $PINS A=a[6] B=a[4] CI=n503 S=n501 CO=n500
XU600 AOI21X1 $PINS A0=n721 A1=n628 B0=n720 Y=n255
XU601 INVX1 $PINS A=n259 Y=n720
XU602 INVX1 $PINS A=n233 Y=n717
XU604 ADDFX2 $PINS A=n479 B=n482 CI=n475 S=n473 CO=n472
XU605 INVX1 $PINS A=n99 Y=n698
XU606 NAND2X1 $PINS A=n304 B=n301 Y=n91
XU607 ADDFX2 $PINS A=n312 B=n307 CI=n310 S=n305 CO=n304
XU608 AOI21X1 $PINS A0=n712 A1=n71 B0=n713 Y=n62
XU609 NOR2X1 $PINS A=n77 B=n74 Y=n70
XU610 XNOR3X2 $PINS A=n504 B=n501 C=n247 Y=product[6]
XU611 NAND2X1 $PINS A=n628 B=n259 Y=n31
XU612 NAND2X1 $PINS A=n623 B=n78 Y=n76
XU613 NAND2X1 $PINS A=n363 B=n374 Y=n169
XU614 NAND2X1 $PINS A=n340 B=n331 Y=n140
XU615 AOI21X1 $PINS A0=n128 A1=n149 B0=n129 Y=n127
XU616 AOI21X1 $PINS A0=n708 A1=n703 B0=n710 Y=n102
XU618 AND2X2 $PINS A=n694 B=n148 Y=n661
XU619 NAND2X1 $PINS A=n399 B=n410 Y=n190
XU621 NOR2X2 $PINS A=n640 B=n219 Y=n214
XU622 NOR2X2 $PINS A=n465 B=n472 Y=n219
XU623 INVX1 $PINS A=n219 Y=n716
XU625 AOI21X1 $PINS A0=n693 A1=n135 B0=n136 Y=n134
XU626 NOR2BX1 $PINS AN=n148 B=n139 Y=n135
XU627 AOI21X1 $PINS A0=n480 A1=n473 B0=n227 Y=n650
XU628 OAI21XL $PINS A0=n123 A1=n698 B0=FE_OFN5902_n100 Y=n92
XU630 NOR2X2 $PINS A=n399 B=n410 Y=n189
XU631 XOR3X2 $PINS A=n412 B=n403 C=n401 Y=n399
XU632 NAND2X1 $PINS A=a[3] B=FE_RN_1 Y=n259
XU634 ADDHX2 $PINS A=a[2] B=a[0] S=n503 CO=n502
XU635 ADDFX2 $PINS A=a[8] B=a[6] CI=n498 S=n491 CO=n490
XU636 OAI21X4 $PINS A0=n711 A1=n189 B0=n190 Y=n188
XU637 XOR2X2 $PINS A=n672 B=n19 Y=product[15]
XU638 NOR2XL $PINS A=n164 B=n157 Y=n679
XU639 ADDFHX1 $PINS A=n367 B=n376 CI=n365 S=n363 CO=n362
XU640 XNOR2X2 $PINS A=n229 B=n650 Y=product[10]
XU641 AOI21X1 $PINS A0=n100 A1=n81 B0=n82 Y=n78
XU642 XOR2X1 $PINS A=n357 B=n368 Y=n662
XU643 XOR2X1 $PINS A=n355 B=n662 Y=n353
XU644 NAND2X1 $PINS A=n368 B=n357 Y=n665
XU645 NAND3X1 $PINS A=n665 B=n663 C=n664 Y=n352
XU646 ADDFX2 $PINS A=n372 B=n370 CI=n359 S=n355 CO=n354
XU647 CMPR22X1 $PINS A=a[3] B=a[0] S=n463 CO=n462
XU649 NAND2BXL $PINS AN=n130 B=n131 Y=n10
XU650 NOR2X1 $PINS A=n101 B=n121 Y=n99
XU651 NOR2BX1 $PINS AN=n242 B=n241 Y=n649
XU652 NAND2X1 $PINS A=n495 B=n500 Y=n242
XU653 NAND2X2 $PINS A=n128 B=n148 Y=n126
XU654 NOR2X2 $PINS A=n157 B=n150 Y=n148
XU655 ADDFHX2 $PINS A=n499 B=n502 CI=n485 S=n495 CO=n494
XU656 INVXL $PINS A=n121 Y=n704
XU657 NAND2X1 $PINS A=n704 B=n122 Y=n9
XU658 NOR2BXL $PINS AN=n84 B=n83 Y=n646
XU659 OAI2BB1X1 $PINS A0N=n100 A1N=n705 B0=n91 Y=n643
XU660 OAI2BB1X1 $PINS A0N=n639 A1N=FE_OCPN6216_n192 B0=n134 Y=n132
XU661 ADDFX2 $PINS A=a[9] B=a[15] CI=a[13] S=n431 CO=n430
XU662 ADDFX2 $PINS A=a[13] B=a[7] CI=a[9] S=n451 CO=n450
XU663 ADDFX2 $PINS A=a[8] B=a[12] CI=a[10] S=n461 CO=n460
XU664 ADDFX2 $PINS A=a[13] B=a[11] CI=n373 S=n369 CO=n368
XU665 ADDFX2 $PINS A=a[13] B=a[15] CI=a[16] S=n347 CO=n346
XU666 ADDFX2 $PINS A=a[11] B=n462 CI=n460 S=n449 CO=n448
XU667 ADDFX2 $PINS A=a[17] B=a[15] CI=n634 S=n327 CO=n326
XU668 ADDFX2 $PINS A=n336 B=n329 CI=n327 S=n325 CO=n324
XU669 NOR2X1 $PINS A=n501 B=n504 Y=n245
XU670 ADDFX2 $PINS A=a[16] B=n303 CI=n306 S=n301 CO=n300
XU671 ADDFX2 $PINS A=n404 B=n393 CI=n402 S=n389 CO=n388
XU672 XOR2X1 $PINS A=n408 B=n612 Y=n393
XU673 ADDFX2 $PINS A=n394 B=n385 CI=n383 S=n379 CO=n378
XU674 ADDFX2 $PINS A=n392 B=n381 CI=n390 S=n377 CO=n376
XU675 NOR2X1 $PINS A=n90 B=n83 Y=n81
XU676 ADDFX2 $PINS A=n382 B=n380 CI=n378 S=n365 CO=n364
XU677 ADDFX2 $PINS A=n334 B=n325 CI=n332 S=n323 CO=n322
XU679 NAND2X1 $PINS A=n455 B=n464 Y=n217
XU681 OAI21XL $PINS A0=n91 A1=n83 B0=n84 Y=n82
XU682 XNOR2X1 $PINS A=n60 B=n2 Y=product[32]
XU683 OAI21XL $PINS A0=n123 A1=n61 B0=n62 Y=n60
XU684 OAI21XL $PINS A0=n692 A1=n139 B0=n140 Y=n136
XU687 OAI21XL $PINS A0=n123 A1=n699 B0=n701 Y=n67
XU688 XOR2X2 $PINS A=n107 B=n709 Y=product[27]
XU690 INVX1 $PINS A=n211 Y=n714
XU691 NAND2X1 $PINS A=n445 B=n454 Y=n211
XU692 ADDFX2 $PINS A=a[2] B=a[4] CI=a[5] S=n471 CO=n470
XU693 XOR2X1 $PINS A=n489 B=n494 Y=n680
XU694 AND2X2 $PINS A=n629 B=n233 Y=n648
XU695 NAND2X1 $PINS A=a[2] B=a[0] Y=n262
XU696 ADDFX2 $PINS A=n366 B=n364 CI=n353 S=n351 CO=n350
XU699 OR2X2 $PINS A=n123 B=n77 Y=n623
XU700 NAND2XL $PINS A=a[12] B=n408 Y=n613
XU701 NAND2XL $PINS A=a[14] B=n408 Y=n614
XU702 NOR2X1 $PINS A=n677 B=n204 Y=n672
XU703 OR2X2 $PINS A=a[3] B=FE_RN_1 Y=n628
XU704 XOR3X2 $PINS A=a[10] B=a[8] C=a[6] Y=n477
XU705 XOR3X2 $PINS A=n485 B=n490 C=n483 Y=n669
XU706 AND2X2 $PINS A=n715 B=n203 Y=n677
XU707 ADDHX1 $PINS A=a[4] B=a[2] S=n507 CO=n506
XU708 ADDFX2 $PINS A=a[5] B=a[7] CI=a[2] S=n443 CO=n442
XU709 NAND2X2 $PINS A=n195 B=n203 Y=n193
XU710 OAI21X2 $PINS A0=n640 A1=n220 B0=n217 Y=n215
XU711 AOI2BB2X2 $PINS A0N=n233 A1N=n227 B0=n480 B1=n473 Y=n224
XU712 ADDFX2 $PINS A=a[5] B=a[2] CI=a[8] S=n409 CO=n408
XU713 AOI21X4 $PINS A0=FE_OCPN6216_n192 A1=n124 B0=n125 Y=n123
XU716 XNOR2X4 $PINS A=n170 B=n14 Y=product[20]
XU717 ADDFX2 $PINS A=a[5] B=a[7] CI=a[3] S=n485 CO=n484
XU718 ADDFX2 $PINS A=a[2] B=FE_RN_1 CI=a[4] S=n493 CO=n492
XU719 OAI21XL $PINS A0=n711 A1=n164 B0=n165 Y=n159
XU720 XOR3X2 $PINS A=n479 B=n482 C=n475 Y=net102349
XU721 OAI21X2 $PINS A0=n719 A1=n241 B0=n242 Y=n240
XU722 OAI2BB2X2 $PINS A0N=n501 A1N=n504 B0=n247 B1=n245 Y=n244
XU724 NAND2BX1 $PINS AN=n640 B=n217 Y=n22
XU725 NOR2X1 $PINS A=n445 B=n454 Y=n210
XU726 NAND2BX2 $PINS AN=n227 B=n629 Y=n223
XU727 NAND2X1 $PINS A=n488 B=n481 Y=n233
XU728 NOR2X1 $PINS A=n238 B=n241 Y=n236
XU729 OAI2BB2X1 $PINS A0N=n489 A1N=n494 B0=n238 B1=n242 Y=n237
XU730 ADDFHX1 $PINS A=n449 B=n456 CI=n447 S=n445 CO=n444
XU731 NOR2X1 $PINS A=n489 B=n494 Y=n238
XU732 OAI21X2 $PINS A0=n202 A1=n200 B0=n201 Y=n199
XU733 ADDFHX1 $PINS A=n485 B=n490 CI=n483 S=n481 CO=n480
XU734 ADDFHX2 $PINS A=a[9] B=n503 CI=n492 S=n483 CO=n482
XU736 ADDFHX2 $PINS A=n484 B=n502 CI=n477 S=n475 CO=n474
XU737 ADDFHX2 $PINS A=n427 B=n436 CI=n425 S=n423 CO=n422
XU738 OR2X2 $PINS A=n669 B=n488 Y=n629
XU739 AOI21X4 $PINS A0=n236 A1=n244 B0=n237 Y=n235
XU740 XNOR2X1 $PINS A=n222 B=n23 Y=product[11]
XU741 NOR2X2 $PINS A=n200 B=n197 Y=n195
XU743 ADDFHX1 $PINS A=n484 B=n493 CI=n491 S=n489 CO=n488
XU744 NOR2X1 $PINS A=n189 B=n186 Y=n184
XU745 AOI21X1 $PINS A0=n252 A1=n632 B0=n678 Y=n247
XU746 OAI2BB2X1 $PINS A0N=n507 A1N=a[0] B0=n255 B1=n253 Y=n252
XU747 NOR2X1 $PINS A=n495 B=n500 Y=n241
XU748 NAND2XL $PINS A=n330 B=n323 Y=n131
XU749 INVXL $PINS A=n90 Y=n705
XU750 NOR2XL $PINS A=n50 B=n5104 Y=n42
XU751 INVX1 $PINS A=n149 Y=n692
XU752 NAND2X1 $PINS A=n705 B=n91 Y=n6
XU753 INVXL $PINS A=n70 Y=n699
XU754 NOR2XL $PINS A=n651 B=n74 Y=n52
XU755 NOR2X2 $PINS A=net102349 B=n480 Y=n227
XU756 OR2XL $PINS A=n40 B=n4988 Y=n631
XU757 NAND2XL $PINS A=n298 B=n297 Y=n75
XU758 OAI21X1 $PINS A0=n150 A1=n158 B0=n726 Y=n149
XU759 NAND2XL $PINS A=n403 B=n412 Y=n621
XU760 ADDFHX4 $PINS A=n415 B=n424 CI=n413 S=n411 CO=n410
XU761 NAND2XL $PINS A=n308 B=n305 Y=n106
XU762 INVX1 $PINS A=n262 Y=n721
XU763 AND2X2 $PINS A=n505 B=n506 Y=n678
XU764 NAND2XL $PINS A=a[6] B=a[10] Y=n609
XU765 XOR2XL $PINS A=a[11] B=a[8] Y=n339
XU766 NAND2BXL $PINS AN=n41 B=a[19] Y=n633
XU767 NOR2XL $PINS A=n294 B=a[17] Y=n58
XU768 NAND2XL $PINS A=n294 B=a[17] Y=n59
XU770 ADDFX2 $PINS A=a[18] B=a[11] CI=a[16] S=n395 CO=n394
XU771 NAND2BXL $PINS AN=n139 B=n140 Y=n11
XU772 NAND2BX1 $PINS AN=n168 B=n169 Y=n14
XU773 NAND2BXL $PINS AN=n150 B=n726 Y=n12
XU774 INVX1 $PINS A=n50 Y=n706
XU775 XNOR2X1 $PINS A=n387 B=n398 Y=n16
XU776 NAND2BX1 $PINS AN=n114 B=n115 Y=n8
XU777 NAND2XL $PINS A=n99 B=n705 Y=n86
XU778 INVX1 $PINS A=n106 Y=n710
XU779 INVX1 $PINS A=n71 Y=n701
XU780 NAND2XL $PINS A=n81 B=n52 Y=n50
XU781 INVX1 $PINS A=n51 Y=n707
XU782 NAND2X1 $PINS A=n712 B=n66 Y=n3
XU783 NAND2BX1 $PINS AN=n58 B=n59 Y=n2
XU784 XOR2X2 $PINS A=n240 B=n680 Y=product[8]
XU785 XNOR2X2 $PINS A=n681 B=n646 Y=product[29]
XU786 NAND2X1 $PINS A=n322 B=n315 Y=n122
XU787 NOR2X1 $PINS A=n314 B=n309 Y=n114
XU788 INVX1 $PINS A=n66 Y=n713
XU789 NAND2X1 $PINS A=n314 B=n309 Y=n115
XU790 INVX1 $PINS A=n65 Y=n712
XU791 NAND2XL $PINS A=n42 B=n99 Y=n40
XU792 XNOR2X1 $PINS A=n39 B=n4988 Y=product[34]
XU793 OAI21XL $PINS A0=n123 A1=n40 B0=n41 Y=n39
XU794 AOI21XL $PINS A0=n82 A1=n52 B0=n53 Y=n51
XU795 OAI221XL $PINS A0=n58 A1=n66 B0=n75 B1=n651 C0=n59 Y=n53
XU796 OR2X2 $PINS A=n65 B=n58 Y=n651
XU797 NAND3X1 $PINS A=n611 B=n609 C=n610 Y=n476
XU798 NAND2X1 $PINS A=a[8] B=a[10] Y=n610
XU799 NAND2X1 $PINS A=a[8] B=a[6] Y=n611
XU800 ADDFX2 $PINS A=a[11] B=a[6] CI=a[8] S=n429 CO=n428
XU801 ADDFX2 $PINS A=a[14] B=a[8] CI=a[10] S=n441 CO=n440
XU802 ADDFX2 $PINS A=n349 B=n356 CI=n354 S=n343 CO=n342
XU803 NAND3X1 $PINS A=n615 B=n613 C=n614 Y=n392
XU804 NAND2X1 $PINS A=a[14] B=a[12] Y=n615
XU805 NOR2X1 $PINS A=n298 B=n297 Y=n74
XU806 NOR2X1 $PINS A=n300 B=n299 Y=n83
XU807 ADDFX2 $PINS A=n326 B=n317 CI=n324 S=n315 CO=n314
XU808 ADDFX2 $PINS A=a[17] B=a[14] CI=n302 S=n299 CO=n298
XU809 ADDFX2 $PINS A=a[17] B=n320 CI=n318 S=n311 CO=n310
XU810 ADDFX2 $PINS A=n321 B=n328 CI=n319 S=n317 CO=n316
XU811 NAND2X1 $PINS A=n300 B=n299 Y=n84
XU812 XNOR2X1 $PINS A=n45 B=n5104 Y=product[33]
XU813 OAI21XL $PINS A0=n123 A1=n46 B0=n47 Y=n45
XU814 AOI21XL $PINS A0=n100 A1=n706 B0=n707 Y=n47
XU815 NAND2XL $PINS A=n99 B=n706 Y=n46
XU816 XOR2XL $PINS A=n31 B=n262 Y=product[3]
XU817 XNOR3X2 $PINS A=n507 B=a[0] C=n255 Y=product[4]
XU818 ADDFX2 $PINS A=n360 B=n358 CI=n347 S=n345 CO=n344
XU819 ADDFX2 $PINS A=a[19] B=a[12] CI=a[17] S=n383 CO=n382
XU820 ADDFX2 $PINS A=n384 B=n371 CI=n369 S=n367 CO=n366
XU821 ADDFX2 $PINS A=a[19] B=a[11] CI=a[14] S=n313 CO=n312
XU822 ADDFX2 $PINS A=a[17] B=n339 CI=n348 S=n335 CO=n334
XU823 ADDFX2 $PINS A=n346 B=n337 CI=n335 S=n333 CO=n332
XU824 XOR2X1 $PINS A=a[12] B=a[14] Y=n612
XU825 AOI2BB2XL $PINS A0N=n51 A1N=n5104 B0=n42 B1=n100 Y=n41
XU826 NAND2X1 $PINS A=n296 B=n295 Y=n66
XU827 NOR2X1 $PINS A=n296 B=n295 Y=n65
XU828 OAI21XL $PINS A0=n123 A1=n631 B0=n633 Y=n33
XU829 ADDFX2 $PINS A=a[14] B=a[18] CI=a[16] S=n371 CO=n370
XU831 ADDFX2 $PINS A=a[6] B=a[5] CI=n463 S=n459 CO=n458
XU832 ADDHXL $PINS A=a[13] B=a[10] S=n321 CO=n320
XU833 ADDFX2 $PINS A=a[18] B=a[9] CI=a[12] S=n329 CO=n328
XU834 ADDHXL $PINS A=a[9] B=FE_OFN94_register_1__6 S=n361 CO=n360
XU835 ADDFX2 $PINS A=a[18] B=a[7] CI=a[10] S=n349 CO=n348
XU836 ADDHXL $PINS A=a[8] B=a[5] S=n373 CO=n372
XU837 CMPR32X1 $PINS A=a[16] B=a[19] C=a[14] S=n337 CO=n336
XU838 ADDHXL $PINS A=a[19] B=a[16] S=n295 CO=n294
XU840 ADDFX2 $PINS A=a[16] B=a[18] CI=a[19] S=n319 CO=n318
XU841 XOR2X1 $PINS A=a[2] B=a[0] Y=product[2]
XU842 ADDFX2 $PINS A=a[18] B=a[12] CI=a[15] S=n307 CO=n306
XU843 ADDFX2 $PINS A=a[15] B=a[13] CI=n396 S=n381 CO=n380
XU844 ADDHXL $PINS A=a[18] B=a[15] S=n297 CO=n296
XU845 ADDHXL $PINS A=a[19] B=a[13] S=n303 CO=n302
XU499 NOR2BX2 $PINS AN=n724 B=n464 Y=n640
XU620 XNOR3X2 $PINS A=n468 B=n466 C=n457 Y=n724
XU629 OR2X2 $PINS A=n189 B=n725 Y=n17
XU678 INVX1 $PINS A=n190 Y=n725
XU742 NAND2X1 $PINS A=n350 B=n341 Y=n726
XU846 XOR2X2 $PINS A=n177 B=n727 Y=product[19]
XU847 AND2X2 $PINS A=n696 B=n176 Y=n727
.ENDS

.SUBCKT CONV_DW_mult_uns_34 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[13] b[12]
+ b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0] product[33]
+ product[32] product[31] product[30] product[29] product[28] product[27]
+ product[26] product[25] product[24] product[23] product[22] product[21]
+ product[20] product[19] product[18] product[17] product[16] product[15]
+ product[14] product[13] product[12] product[11] product[10] product[9]
+ product[8] product[7] product[6] product[5] product[4] product[3] product[2]
+ product[1] product[0] p1 p2 p3 p4 p5 p6 p7 p8 p9 p10 p11 p12 p13 p14 p15 p16
+ p17 p18 FE_OFN14_register_4__16 _register_4_14 _register_4_8 _register_4_11
+ _register_4_10 _register_4_16 FE_OFN76_register_4__12 FE_OFN97_n6728
XFE_OFC2079_n6728 INVX1 $PINS A=p1 Y=FE_OFN6070_n6728
XFE_OFC1906_n4938 INVX1 $PINS A=a[3] Y=FE_OFN5937_n4938
XFE_OFC1861_n100 INVX1 $PINS A=n100 Y=n429
XFE_OFC1695_n178 INVXL $PINS A=n178 Y=n417
XFE_OFC1394_n135 CLKINVX3 $PINS A=FE_DBTN1189_n135 Y=FE_OFN5670_n135
XFE_OFC1393_n135 CLKINVX8 $PINS A=n135 Y=FE_DBTN1189_n135
XFE_OFC1339_n165 INVX1 $PINS A=n165 Y=FE_DBTN182_n165
XFE_OFC170_n454 INVX1 $PINS A=n454 Y=n393
XU151 OAI21X2 $PINS A0=n156 A1=n136 B0=n137 Y=n135
XU154 NOR2X1 $PINS A=n143 B=n140 Y=n138
XU184 AOI21X2 $PINS A0=n157 A1=n165 B0=n158 Y=n156
XU199 OAI21X1 $PINS A0=n166 A1=n178 B0=n167 Y=n165
XU310 XNOR2X2 $PINS A=n142 B=n15 Y=product[19]
XU466 AND2X2 $PINS A=n32 B=p17 Y=n384
XU323 XOR3X2 $PINS A=n113 B=n237 C=n240 Y=product[23]
XU345 XOR2X4 $PINS A=FE_DBTN1189_n135 B=n405 Y=product[20]
XU377 OAI31X1 $PINS A0=FE_DBTN1189_n135 A1=n107 A2=n100 B0=n386 Y=n95
XU419 XOR2X1 $PINS A=n75 B=n406 Y=product[27]
XU427 AOI21X1 $PINS A0=n179 A1=n187 B0=n180 Y=n178
XU469 NAND2X1 $PINS A=n91 B=n71 Y=n69
XU504 AND2X2 $PINS A=n383 B=n37 Y=n407
XU306 OAI21XL $PINS A0=FE_DBTN1189_n135 A1=n76 B0=n77 Y=n75
XU307 NOR2X1 $PINS A=n107 B=n69 Y=n67
XU308 OR2X2 $PINS A=n403 B=n133 Y=n408
XU309 NAND2X1 $PINS A=n408 B=n130 Y=n399
XU311 NOR2X1 $PINS A=n245 B=n248 Y=n403
XU312 NAND2X1 $PINS A=n245 B=n248 Y=n130
XU313 NAND2X1 $PINS A=n385 B=n399 Y=n394
XU314 ADDFX2 $PINS A=p9 B=_register_4_8 CI=a[13] S=n247 CO=n246
XU315 ADDFX2 $PINS A=_register_4_8 B=a[5] CI=n279 S=n277 CO=n276
XU316 OAI21XL $PINS A0=n93 A1=n101 B0=n94 Y=n92
XU317 NAND2XL $PINS A=n233 B=n236 Y=n101
XU318 NOR2X1 $PINS A=n232 B=n229 Y=n93
XU319 NOR2X1 $PINS A=n221 B=n224 Y=n73
XU320 ADDFX2 $PINS A=a[19] B=n223 CI=n226 S=n221 CO=n220
XU321 ADDFX2 $PINS A=p17 B=n227 CI=n230 S=n225 CO=n224
XU322 OAI21XL $PINS A0=FE_DBTN1189_n135 A1=n132 B0=n133 Y=n131
XU324 ADDFX2 $PINS A=a[6] B=p5 CI=_register_4_10 S=n259 CO=n258
XU326 INVX1 $PINS A=n171 Y=n422
XU328 ADDFX2 $PINS A=p13 B=n262 CI=n259 S=n257 CO=n256
XU329 OAI21XL $PINS A0=n140 A1=n144 B0=n141 Y=n139
XU330 ADDFX2 $PINS A=_register_4_14 B=n258 CI=n255 S=n253 CO=n252
XU332 ADDFX2 $PINS A=a[18] B=n242 CI=n239 S=n237 CO=n236
XU333 ADDFX2 $PINS A=FE_OFN97_n6728 B=n231 CI=n234 S=n229 CO=n228
XU335 OAI21XL $PINS A0=n66 A1=n64 B0=n65 Y=n59
XU337 OAI21XL $PINS A0=FE_DBTN1189_n135 A1=n114 B0=n115 Y=n113
XU338 NAND2X1 $PINS A=n265 B=n268 Y=n154
XU339 NAND2X1 $PINS A=n381 B=n382 Y=n166
XU340 NAND2X1 $PINS A=n273 B=n276 Y=n163
XU341 NOR2X1 $PINS A=n184 B=n181 Y=n179
XU342 NOR2X1 $PINS A=n265 B=n268 Y=n153
XU343 AND2X2 $PINS A=n390 B=n391 Y=n385
XU344 OAI21XL $PINS A0=n181 A1=n185 B0=n182 Y=n180
XU346 NOR2X1 $PINS A=n273 B=n276 Y=n162
XU347 AOI221X1 $PINS A0=n399 A1=n385 B0=n237 B1=n240 C0=n454 Y=n104
XU348 XNOR2X1 $PINS A=n41 B=n3 Y=product[31]
XU349 OAI2BB1X1 $PINS A0N=n393 A1N=n394 B0=n409 Y=n425
XU350 INVX1 $PINS A=n69 Y=n409
XU351 XOR2X1 $PINS A=n178 B=n22 Y=product[12]
XU352 NAND2BX1 $PINS AN=n107 B=n78 Y=n76
XU353 AOI22X1 $PINS A0=n395 A1=n390 B0=n241 B1=n244 Y=n115
XU354 OAI21XL $PINS A0=n73 A1=n83 B0=n74 Y=n72
XU355 AOI21X1 $PINS A0=FE_OFN5670_n135 A1=n127 B0=n395 Y=n410
XU356 INVX1 $PINS A=n410 Y=n120
XU357 NOR2X1 $PINS A=n228 B=n225 Y=n82
XU359 AND4X2 $PINS A=n376 B=n400 C=n101 D=n401 Y=n386
XU360 OAI21XL $PINS A0=n188 A1=n190 B0=n189 Y=n187
XU361 NAND2BX1 $PINS AN=n153 B=n154 Y=n18
XU362 XNOR2X1 $PINS A=n95 B=n9 Y=product[25]
XU363 XNOR2X1 $PINS A=n374 B=n17 Y=product[17]
XU364 OAI21XL $PINS A0=n416 A1=n184 B0=n185 Y=n183
XU365 INVX1 $PINS A=n187 Y=n416
XU366 XNOR2X1 $PINS A=n131 B=n13 Y=product[21]
XU367 NOR2X1 $PINS A=n261 B=n264 Y=n148
XU368 NOR2BX1 $PINS AN=n160 B=n159 Y=n414
XU370 OR2X2 $PINS A=n241 B=n244 Y=n390
XU371 AOI21X1 $PINS A0=n417 A1=n382 B0=n435 Y=n172
XU373 OAI21XL $PINS A0=n427 A1=n82 B0=n83 Y=n79
XU374 OAI21XL $PINS A0=n156 A1=n153 B0=n154 Y=n374
XU375 XOR3X2 $PINS A=n84 B=n228 C=n225 Y=product[26]
XU376 NAND2X1 $PINS A=n281 B=p4 Y=n176
XU378 NOR2X2 $PINS A=n269 B=n272 Y=n159
XU379 ADDFX2 $PINS A=p9 B=n278 CI=n275 S=n273 CO=n272
XU380 XNOR2X1 $PINS A=n120 B=n12 Y=product[22]
XU381 ADDFX2 $PINS A=FE_OFN6070_n6728 B=n246 CI=n243 S=n241 CO=n240
XU382 ADDFX2 $PINS A=p3 B=a[1] CI=p6 S=n275 CO=n274
XU385 ADDFX2 $PINS A=_register_4_16 B=n250 CI=n247 S=n245 CO=n244
XU387 NOR2X1 $PINS A=n82 B=n73 Y=n71
XU388 OAI21X1 $PINS A0=n145 A1=n143 B0=n144 Y=n142
XU389 ADDFX2 $PINS A=a[3] B=p3 CI=p7 S=n271 CO=n270
XU390 ADDFX2 $PINS A=a[4] B=a[3] CI=p8 S=n267 CO=n266
XU391 ADDFX2 $PINS A=p5 B=a[4] CI=a[9] S=n263 CO=n262
XU393 ADDFX2 $PINS A=p10 B=p9 CI=p14 S=n243 CO=n242
XU395 OR2X2 $PINS A=n237 B=n240 Y=n391
XU398 XNOR2X1 $PINS A=n419 B=n18 Y=product[16]
XU399 XOR2X1 $PINS A=n161 B=n414 Y=product[15]
XU400 OAI21XL $PINS A0=FE_DBTN182_n165 A1=n162 B0=n163 Y=n161
XU402 XOR2X1 $PINS A=n172 B=n21 Y=product[13]
XU403 XOR2X1 $PINS A=n416 B=n24 Y=product[10]
XU404 INVX1 $PINS A=n104 Y=n423
XU406 XNOR2X1 $PINS A=n102 B=n10 Y=product[24]
XU407 OAI21XL $PINS A0=FE_DBTN1189_n135 A1=n107 B0=n104 Y=n102
XU408 ADDFX2 $PINS A=_register_4_11 B=p10 CI=p15 S=n239 CO=n238
XU409 ADDFX2 $PINS A=FE_OFN76_register_4__12 B=_register_4_11 CI=p16 S=n235
+ CO=n234
XU410 AOI21X2 $PINS A0=n138 A1=n147 B0=n139 Y=n137
XU411 NAND2X1 $PINS A=n146 B=n138 Y=n136
XU412 NOR2X1 $PINS A=n153 B=n148 Y=n146
XU413 NOR2BXL $PINS AN=n182 B=n181 Y=n404
XU414 XOR2X2 $PINS A=n145 B=n16 Y=product[18]
XU415 AOI21X1 $PINS A0=n423 A1=n78 B0=n79 Y=n77
XU416 NOR2X1 $PINS A=n428 B=n82 Y=n78
XU417 ADDFX2 $PINS A=p10 B=n274 CI=n271 S=n269 CO=n268
XU420 ADDFX2 $PINS A=_register_4_11 B=n270 CI=n267 S=n265 CO=n264
XU421 ADDHXL $PINS A=a[1] B=a[0] S=n279 CO=n278
XU422 XOR2X2 $PINS A=n66 B=n6 Y=product[28]
XU423 ADDHXL $PINS A=FE_OFN76_register_4__12 B=p13 S=n231 CO=n230
XU424 XOR2XL $PINS A=a[0] B=a[3] Y=product[8]
XU425 NAND2BX1 $PINS AN=n148 B=n149 Y=n17
XU428 NOR2X1 $PINS A=n100 B=n93 Y=n91
XU429 OAI21XL $PINS A0=n440 A1=n65 B0=n58 Y=n52
XU430 NAND3X1 $PINS A=n388 B=n70 C=n425 Y=n68
XU431 OR2X2 $PINS A=n69 B=n112 Y=n388
XU432 NAND2BXL $PINS AN=n100 B=n101 Y=n10
XU435 ADDFX2 $PINS A=_register_4_8 B=a[7] CI=a[12] S=n251 CO=n250
XU436 ADDHXL $PINS A=a[7] B=a[0] S=n281 CO=n280
XU437 ADDHXL $PINS A=p13 B=_register_4_14 S=n227 CO=n226
XU438 ADDHXL $PINS A=_register_4_14 B=a[15] S=n223 CO=n222
XU439 ADDFX2 $PINS A=p12 B=n266 CI=n263 S=n261 CO=n260
XU440 ADDFX2 $PINS A=a[15] B=n254 CI=n251 S=n249 CO=n248
XU441 ADDFX2 $PINS A=p18 B=n238 CI=n235 S=n233 CO=n232
XU442 INVX1 $PINS A=n176 Y=n435
XU443 OR2X2 $PINS A=n277 B=n280 Y=n381
XU444 ADDFX2 $PINS A=a[15] B=p16 CI=n222 S=n218 CO=n217
XU445 NAND2X1 $PINS A=n257 B=n260 Y=n144
XU446 NOR2X1 $PINS A=n253 B=n256 Y=n140
XU447 NOR2X1 $PINS A=n257 B=n260 Y=n143
XU448 NAND2X1 $PINS A=n249 B=n252 Y=n133
XU449 NOR2X1 $PINS A=n249 B=n252 Y=n132
XU450 NOR2X1 $PINS A=n132 B=n403 Y=n127
XU451 NOR2X1 $PINS A=n233 B=n236 Y=n100
XU452 INVX1 $PINS A=n91 Y=n428
XU453 XOR2X1 $PINS A=FE_DBTN182_n165 B=n20 Y=product[14]
XU454 XOR2X1 $PINS A=n183 B=n404 Y=product[11]
XU455 XNOR2X1 $PINS A=n48 B=n4 Y=product[30]
XU456 OAI21XL $PINS A0=n66 A1=n31 B0=n32 Y=n30
XU457 NOR2X1 $PINS A=FE_OFN5937_n4938 B=a[6] Y=n181
XU458 NOR2BXL $PINS AN=a[0] B=a[3] Y=n190
XU459 OAI31X1 $PINS A0=FE_DBTN1189_n135 A1=n428 A2=n107 B0=n86 Y=n84
XU460 AOI2BB1X1 $PINS A0N=n392 A1N=n428 B0=n92 Y=n86
XU461 OAI21XL $PINS A0=n159 A1=n163 B0=n160 Y=n158
XU462 NAND2BXL $PINS AN=n162 B=n163 Y=n20
XU463 NAND2X1 $PINS A=n228 B=n225 Y=n83
XU464 OAI21XL $PINS A0=n403 A1=n133 B0=n130 Y=n395
XU465 NAND2BXL $PINS AN=n403 B=n130 Y=n13
XU467 OAI21XL $PINS A0=n66 A1=n439 B0=n438 Y=n48
XU468 OAI21XL $PINS A0=n66 A1=n42 B0=n43 Y=n41
XU470 AOI21X2 $PINS A0=n67 A1=FE_OFN5670_n135 B0=n68 Y=n66
XU471 NOR2X1 $PINS A=n159 B=n162 Y=n157
XU472 OAI21X2 $PINS A0=n148 A1=n154 B0=n149 Y=n147
XU473 AOI21X1 $PINS A0=n435 A1=n381 B0=n422 Y=n167
XU474 NAND2XL $PINS A=n381 B=n171 Y=n21
XU475 ADDFX2 $PINS A=a[7] B=a[6] CI=p11 S=n255 CO=n254
XU476 AOI21X1 $PINS A0=n92 A1=n71 B0=n72 Y=n70
XU477 NAND2BXL $PINS AN=n143 B=n144 Y=n16
XU480 INVX2 $PINS A=n156 Y=n419
XU481 NOR2BXL $PINS AN=n74 B=n73 Y=n406
XU482 NAND2XL $PINS A=n454 B=n429 Y=n400
XU483 AOI21X1 $PINS A0=n395 A1=n385 B0=n396 Y=n392
XU484 NAND2XL $PINS A=n393 B=n112 Y=n396
XU485 NAND2BXL $PINS AN=n64 B=n65 Y=n6
XU486 NAND2BXL $PINS AN=n64 B=n407 Y=n31
XU487 XOR2X1 $PINS A=n30 B=p17 Y=product[32]
XU488 NAND2XL $PINS A=n217 B=FE_OFN97_n6728 Y=n58
XU489 OR2XL $PINS A=n217 B=FE_OFN97_n6728 Y=n383
XU490 NAND2X1 $PINS A=n253 B=n256 Y=n141
XU491 INVXL $PINS A=n58 Y=n441
XU492 INVXL $PINS A=n65 Y=n442
XU493 NOR2X1 $PINS A=p2 B=a[4] Y=n188
XU494 NOR2XL $PINS A=a[2] B=p5 Y=n184
XU495 NAND2XL $PINS A=a[2] B=p5 Y=n185
XU500 INVX1 $PINS A=n92 Y=n427
XU501 NAND3XL $PINS A=n429 B=n395 C=n385 Y=n401
XU502 INVX1 $PINS A=n51 Y=n439
XU503 NAND2X1 $PINS A=n415 B=n127 Y=n107
XU505 AND2X1 $PINS A=n391 B=n390 Y=n415
XU506 NAND2BXL $PINS AN=n132 B=n133 Y=n405
XU507 NAND2BXL $PINS AN=n93 B=n94 Y=n9
XU508 NAND2XL $PINS A=n390 B=n119 Y=n12
XU509 NAND2BXL $PINS AN=n140 B=n141 Y=n15
XU511 NOR2X1 $PINS A=n64 B=n440 Y=n51
XU513 NAND2X1 $PINS A=n221 B=n224 Y=n74
XU514 NAND2X1 $PINS A=n382 B=n176 Y=n22
XU515 INVX1 $PINS A=n383 Y=n440
XU516 OR2XL $PINS A=n100 B=n112 Y=n376
XU517 NAND2X1 $PINS A=n261 B=n264 Y=n149
XU518 NAND2X1 $PINS A=n277 B=n280 Y=n171
XU519 NAND2XL $PINS A=n127 B=n390 Y=n114
XU520 AOI221X1 $PINS A0=n442 A1=n407 B0=n441 B1=n37 C0=n38 Y=n32
XU521 OAI21XL $PINS A0=n39 A1=n47 B0=n40 Y=n38
XU522 NOR2X1 $PINS A=n220 B=n218 Y=n64
XU523 NAND2X1 $PINS A=n220 B=n218 Y=n65
XU524 NAND2X1 $PINS A=n237 B=n240 Y=n112
XU525 NAND2BX1 $PINS AN=n184 B=n185 Y=n24
XU526 OR2X2 $PINS A=n281 B=p4 Y=n382
XU527 NAND2X1 $PINS A=n269 B=n272 Y=n160
XU528 NAND2X1 $PINS A=n232 B=n229 Y=n94
XU529 NAND2XL $PINS A=n241 B=n244 Y=n119
XU530 XOR2XL $PINS A=n25 B=n190 Y=product[9]
XU531 NAND2BX1 $PINS AN=n188 B=n189 Y=n25
XU532 NAND2X1 $PINS A=n436 B=n47 Y=n4
XU533 INVX1 $PINS A=n52 Y=n438
XU534 NAND2BX1 $PINS AN=n39 B=n40 Y=n3
XU535 NAND2X1 $PINS A=n51 B=n436 Y=n42
XU537 INVX1 $PINS A=n46 Y=n436
XU538 NOR2X1 $PINS A=n46 B=n39 Y=n37
XU541 AOI22XL $PINS A0=p17 A1=_register_4_16 B0=n436 B1=n52 Y=n43
XU542 NAND2XL $PINS A=p2 B=a[4] Y=n189
XU543 NAND2XL $PINS A=FE_OFN5937_n4938 B=a[6] Y=n182
XU544 XNOR2XL $PINS A=n26 B=p18 Y=product[33]
XU545 OAI21XL $PINS A0=n66 A1=n31 B0=n384 Y=n26
XU546 NOR2XL $PINS A=a[19] B=a[17] Y=n39
XU547 NOR2XL $PINS A=p17 B=_register_4_16 Y=n46
XU548 NAND2XL $PINS A=p17 B=_register_4_16 Y=n47
XU549 NAND2XL $PINS A=a[19] B=a[17] Y=n40
XU336 AND3X2 $PINS A=n244 B=n241 C=n391 Y=n454
XU394 XOR2X1 $PINS A=n59 B=n455 Y=product[29]
XU401 AND2X2 $PINS A=n383 B=n58 Y=n455
XU510 NOR2BX4 $PINS AN=n457 B=n147 Y=n145
XU550 NAND2X1 $PINS A=n146 B=n419 Y=n457
.ENDS

.SUBCKT CONV_DW01_add_27 A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[34]
+ B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21]
+ B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8]
+ B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[34] SUM[33] SUM[32] SUM[31]
+ SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24] SUM[23] SUM[22]
+ SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15] SUM[14] SUM[13]
+ SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3]
+ SUM[2] SUM[1] SUM[0] CO
*.CONNECT SUM[34] n33
*.CONNECT SUM[0] B[0]
*.CONNECT SUM[1] B[1]
*.CONNECT SUM[2] B[2]
*.CONNECT SUM[3] B[3]
*.CONNECT SUM[4] B[4]
XFE_OCPC2327_FE_OFN146_n150 BUFX8 $PINS A=FE_OFN146_n150
+ Y=FE_OCPN6231_FE_OFN146_n150
XFE_OFC2093_n191 INVX1 $PINS A=n446 Y=FE_OFN6076_n191
XFE_OFC2092_n191 INVX2 $PINS A=n191 Y=n446
XFE_OFC1358_n150 INVX1 $PINS A=FE_OCPN6231_FE_OFN146_n150 Y=FE_OFN5652_n150
XFE_OFC1357_n150 BUFX8 $PINS A=n150 Y=FE_OFN146_n150
XFE_OFC231_n15 INVX1 $PINS A=n15 Y=n463
XFE_DBTC181_n124 INVX2 $PINS A=n124 Y=FE_DBTN181_n124
XU67 XNOR2X1 $PINS A=n91 B=n9 Y=SUM[28]
XU73 NAND2X1 $PINS A=n107 B=n87 Y=n85
XU75 NOR2X2 $PINS A=n98 B=n89 Y=n87
XU81 XNOR2X2 $PINS A=n100 B=n10 Y=SUM[27]
XU91 NOR2X1 $PINS A=A[27] B=B[27] Y=n98
XU93 XNOR2X2 $PINS A=n111 B=n11 Y=SUM[26]
XU101 NOR2X2 $PINS A=n116 B=n109 Y=n107
XU108 OAI21X2 $PINS A0=FE_OCPN6231_FE_OFN146_n150 A1=n112 B0=n113 Y=n111
XU115 NOR2X1 $PINS A=A[25] B=B[25] Y=n116
XU124 AOI21X4 $PINS A0=n125 A1=n144 B0=n126 Y=n124
XU125 NOR2X2 $PINS A=n134 B=n127 Y=n125
XU129 NOR2X2 $PINS A=A[24] B=B[24] Y=n127
XU139 NOR2X1 $PINS A=A[23] B=B[23] Y=n134
XU142 OAI21X2 $PINS A0=FE_OFN146_n150 A1=n427 B0=n424 Y=n136
XU150 OAI21X2 $PINS A0=n145 A1=n149 B0=n146 Y=n144
XU153 NOR2X1 $PINS A=A[22] B=B[22] Y=n145
XU155 XOR2X2 $PINS A=FE_OFN146_n150 B=n16 Y=SUM[21]
XU163 NOR2X1 $PINS A=FE_OFN6076_n191 B=n153 Y=n151
XU165 NAND2X1 $PINS A=n175 B=n402 Y=n153
XU171 NOR2X2 $PINS A=A[20] B=B[20] Y=n157
XU183 NOR2X4 $PINS A=A[19] B=B[19] Y=n166
XU193 NOR2X2 $PINS A=n177 B=n184 Y=n175
XU197 NOR2X2 $PINS A=A[18] B=B[18] Y=n177
XU216 AOI21X4 $PINS A0=n193 A1=n212 B0=n194 Y=n192
XU217 NOR2X2 $PINS A=n195 B=n202 Y=n193
XU221 NOR2X2 $PINS A=A[16] B=B[16] Y=n195
XU258 NOR2X1 $PINS A=n224 B=n227 Y=n222
XU268 NOR2X1 $PINS A=A[11] B=B[11] Y=n227
XU289 NOR2X2 $PINS A=n243 B=n246 Y=n241
XU290 OAI21X2 $PINS A0=n243 A1=n247 B0=n244 Y=n242
XU370 AND2X2 $PINS A=n222 B=n230 Y=n401
XU422 NOR2X2 $PINS A=A[26] B=B[26] Y=n109
XU461 AND2X2 $PINS A=n400 B=n253 Y=SUM[5]
XU472 OAI2BB1X4 $PINS A0N=n451 A1N=n401 B0=n221 Y=n219
XU481 OAI21X2 $PINS A0=n449 A1=n216 B0=n460 Y=n215
XU489 OAI21X2 $PINS A0=n192 A1=n153 B0=n154 Y=n152
XU490 AOI21X2 $PINS A0=n402 A1=n176 B0=n156 Y=n154
XU518 XOR2X1 $PINS A=n80 B=n410 Y=SUM[29]
XU358 NOR2X1 $PINS A=A[30] B=B[30] Y=n71
XU443 OAI21X2 $PINS A0=FE_OCPN6231_FE_OFN146_n150 A1=n123 B0=n124 Y=n118
XU462 XNOR2X2 $PINS A=n129 B=n13 Y=SUM[24]
XU316 NAND2X1 $PINS A=A[14] B=B[14] Y=n214
XU317 INVX1 $PINS A=n203 Y=n447
XU318 INVX1 $PINS A=n192 Y=n444
XU319 OAI21XL $PINS A0=n449 A1=n191 B0=n192 Y=n186
XU320 NOR2X1 $PINS A=n47 B=n40 Y=n36
XU322 XNOR2X4 $PINS A=n226 B=n25 Y=SUM[12]
XU323 XNOR2X2 $PINS A=n73 B=n7 Y=SUM[30]
XU324 INVX1 $PINS A=n78 Y=n436
XU325 AND2X2 $PINS A=n448 B=n212 Y=n411
XU326 NOR2X1 $PINS A=n411 B=n447 Y=n199
XU327 OAI21X1 $PINS A0=n449 A1=n198 B0=n199 Y=n197
XU328 NAND2X1 $PINS A=FE_DBTN181_n124 B=n413 Y=n414
XU329 NAND2X2 $PINS A=n414 B=n86 Y=n84
XU330 INVX1 $PINS A=n85 Y=n413
XU331 AOI21X1 $PINS A0=n87 A1=n108 B0=n88 Y=n86
XU332 INVX1 $PINS A=n84 Y=n426
XU333 XOR2X1 $PINS A=n31 B=n253 Y=SUM[6]
XU336 NOR2X1 $PINS A=n60 B=n51 Y=n49
XU337 NAND2BX1 $PINS AN=n145 B=n146 Y=n15
XU338 NOR2X1 $PINS A=A[29] B=B[29] Y=n78
XU339 INVX1 $PINS A=n212 Y=n443
XU340 NOR2X1 $PINS A=A[17] B=B[17] Y=n184
XU341 NAND2X1 $PINS A=B[13] B=A[13] Y=n217
XU342 NAND2X1 $PINS A=A[29] B=B[29] Y=n79
XU343 NAND2X1 $PINS A=A[30] B=B[30] Y=n72
XU344 NOR2BX1 $PINS AN=n196 B=n195 Y=n409
XU345 NAND2X1 $PINS A=A[18] B=B[18] Y=n178
XU346 NAND2BX1 $PINS AN=n148 B=n149 Y=n16
XU347 NOR2X1 $PINS A=A[21] B=B[21] Y=n148
XU348 INVX1 $PINS A=n144 Y=n424
XU349 NAND2X1 $PINS A=A[23] B=B[23] Y=n135
XU350 NAND2X1 $PINS A=A[26] B=B[26] Y=n110
XU351 XNOR2X1 $PINS A=n29 B=n245 Y=SUM[8]
XU352 XOR2X2 $PINS A=n234 B=n27 Y=SUM[10]
XU353 OAI21XL $PINS A0=FE_OCPN6231_FE_OFN146_n150 A1=n34 B0=n35 Y=n33
XU354 OAI21XL $PINS A0=n48 A1=n40 B0=n41 Y=n37
XU355 OAI2BB1X1 $PINS A0N=n249 A1N=n452 B0=n247 Y=n245
XU356 INVX1 $PINS A=n246 Y=n452
XU357 OAI21X2 $PINS A0=n213 A1=n217 B0=n214 Y=n212
XU359 NAND2BX1 $PINS AN=n243 B=n244 Y=n29
XU360 NOR2X2 $PINS A=n166 B=n157 Y=n402
XU361 NAND2BX1 $PINS AN=n237 B=n238 Y=n407
XU362 NAND2X1 $PINS A=n211 B=n193 Y=n191
XU364 NAND2X1 $PINS A=n448 B=n211 Y=n198
XU365 NAND2BXL $PINS AN=n98 B=n99 Y=n10
XU366 XOR2X2 $PINS A=n197 B=n409 Y=SUM[16]
XU367 AOI2BB1X1 $PINS A0N=n192 A1N=n184 B0=n441 Y=n181
XU368 AOI21XL $PINS A0=n423 A1=n84 B0=n422 Y=n44
XU369 NAND2BX1 $PINS AN=n250 B=n251 Y=n31
XU371 AOI21XL $PINS A0=n436 A1=n84 B0=n437 Y=n75
XU372 NAND2X1 $PINS A=n446 B=n439 Y=n180
XU373 INVX1 $PINS A=n184 Y=n439
XU375 OAI21XL $PINS A0=n51 A1=n61 B0=n52 Y=n50
XU376 NAND2BX1 $PINS AN=n177 B=n178 Y=n19
XU378 AND2X2 $PINS A=n175 B=n446 Y=n420
XU380 XOR2X2 $PINS A=n229 B=n26 Y=SUM[11]
XU381 XNOR2X1 $PINS A=n249 B=n30 Y=SUM[7]
XU382 AOI2BB1X1 $PINS A0N=n124 A1N=n434 B0=n108 Y=n102
XU383 NAND2XL $PINS A=n423 B=n83 Y=n43
XU384 AOI21X2 $PINS A0=n451 A1=n230 B0=n231 Y=n229
XU385 CLKINVX3 $PINS A=n240 Y=n451
XU386 NOR2BX1 $PINS AN=n69 B=n60 Y=n56
XU387 OAI2BB1X1 $PINS A0N=n219 A1N=n420 B0=n170 Y=n168
XU390 XNOR2X1 $PINS A=n204 B=n22 Y=SUM[15]
XU391 OAI21X1 $PINS A0=n449 A1=n445 B0=n443 Y=n204
XU392 NAND2X1 $PINS A=A[7] B=B[7] Y=n247
XU394 INVX1 $PINS A=n116 Y=n433
XU395 NAND2X1 $PINS A=n203 B=n448 Y=n22
XU397 AOI21XL $PINS A0=n431 A1=n144 B0=n430 Y=n131
XU398 AOI21X1 $PINS A0=FE_DBTN181_n124 A1=n433 B0=n432 Y=n113
XU399 OAI21X1 $PINS A0=FE_OFN146_n150 A1=n148 B0=n149 Y=n147
XU400 NAND2X1 $PINS A=A[24] B=B[24] Y=n128
XU401 NOR2X1 $PINS A=A[7] B=B[7] Y=n246
XU402 NOR2X1 $PINS A=A[15] B=B[15] Y=n202
XU403 OAI21X1 $PINS A0=n127 A1=n135 B0=n128 Y=n126
XU405 NAND2X1 $PINS A=A[15] B=B[15] Y=n203
XU406 NAND2X1 $PINS A=A[17] B=B[17] Y=n185
XU407 NAND2X1 $PINS A=A[19] B=B[19] Y=n167
XU408 NAND2X1 $PINS A=A[20] B=B[20] Y=n158
XU409 AND2X2 $PINS A=n162 B=n446 Y=n416
XU410 NAND2X1 $PINS A=A[21] B=B[21] Y=n149
XU411 NAND2X1 $PINS A=A[27] B=B[27] Y=n99
XU412 INVX1 $PINS A=n123 Y=n428
XU413 OAI2BB1X1 $PINS A0N=FE_OFN5652_n150 A1N=n405 B0=n75 Y=n73
XU414 XNOR2X1 $PINS A=n136 B=n406 Y=SUM[23]
XU415 XNOR2X2 $PINS A=n62 B=n6 Y=SUM[31]
XU416 NAND2BX1 $PINS AN=n60 B=n61 Y=n6
XU418 XNOR2X1 $PINS A=n42 B=n4 Y=SUM[33]
XU419 NAND2BXL $PINS AN=n51 B=n52 Y=n5
XU420 OAI21X1 $PINS A0=n449 A1=n180 B0=n181 Y=n179
XU421 OAI2BB1X1 $PINS A0N=n219 A1N=n416 B0=n161 Y=n159
XU423 NOR2BX1 $PINS AN=n175 B=n166 Y=n162
XU424 XNOR2X1 $PINS A=n179 B=n19 Y=SUM[18]
XU425 INVXL $PINS A=n166 Y=n442
XU426 NAND2X1 $PINS A=A[5] B=B[5] Y=n253
XU427 NAND2BXL $PINS AN=n224 B=n225 Y=n25
XU428 AND2X1 $PINS A=n83 B=n436 Y=n405
XU429 NAND2XL $PINS A=n83 B=n69 Y=n63
XU430 INVX1 $PINS A=n83 Y=n429
XU431 AOI21XL $PINS A0=n84 A1=n56 B0=n57 Y=n55
XU432 OAI21XL $PINS A0=n438 A1=n60 B0=n61 Y=n57
XU433 AOI21X1 $PINS A0=n84 A1=n69 B0=n70 Y=n64
XU434 OAI21XL $PINS A0=n89 A1=n99 B0=n90 Y=n88
XU435 NOR2X1 $PINS A=A[28] B=B[28] Y=n89
XU437 NOR2BX1 $PINS AN=n107 B=n98 Y=n94
XU438 XOR2X2 $PINS A=n449 B=n24 Y=SUM[13]
XU439 NAND2X1 $PINS A=n452 B=n247 Y=n30
XU440 OAI21X2 $PINS A0=n250 A1=n253 B0=n251 Y=n249
XU441 OAI21X1 $PINS A0=n195 A1=n203 B0=n196 Y=n194
XU442 INVX1 $PINS A=n211 Y=n445
XU445 NAND2X1 $PINS A=A[16] B=B[16] Y=n196
XU446 INVX1 $PINS A=n202 Y=n448
XU447 NOR2X1 $PINS A=B[6] B=A[6] Y=n250
XU448 NAND2X1 $PINS A=A[6] B=B[6] Y=n251
XU449 NAND2X1 $PINS A=A[11] B=B[11] Y=n228
XU450 NAND2X1 $PINS A=A[9] B=B[9] Y=n238
XU452 AND2X2 $PINS A=n436 B=n79 Y=n410
XU453 INVX1 $PINS A=n70 Y=n438
XU454 NOR2X1 $PINS A=A[31] B=B[31] Y=n60
XU455 NAND2BX1 $PINS AN=n166 B=n167 Y=n18
XU456 OAI21X1 $PINS A0=FE_OFN146_n150 A1=n130 B0=n131 Y=n129
XU457 OAI21XL $PINS A0=FE_OCPN6231_FE_OFN146_n150 A1=n101 B0=n102 Y=n100
XU458 NAND2X1 $PINS A=n143 B=n431 Y=n130
XU459 AOI2BB1X2 $PINS A0N=n240 A1N=n237 B0=n450 Y=n234
XU460 XNOR2X2 $PINS A=n451 B=n407 Y=SUM[9]
XU463 NAND2X1 $PINS A=A[32] B=B[32] Y=n52
XU464 XNOR2X2 $PINS A=n159 B=n17 Y=SUM[20]
XU465 INVX1 $PINS A=n238 Y=n450
XU466 OAI21X2 $PINS A0=n157 A1=n167 B0=n158 Y=n156
XU467 NAND2BX1 $PINS AN=n213 B=n214 Y=n23
XU468 NOR2X2 $PINS A=B[8] B=A[8] Y=n243
XU469 AOI21X1 $PINS A0=n49 A1=n70 B0=n50 Y=n48
XU470 AOI21X1 $PINS A0=n444 A1=n175 B0=n176 Y=n170
XU471 OAI21XL $PINS A0=n224 A1=n228 B0=n225 Y=n223
XU473 NOR2X1 $PINS A=n237 B=n403 Y=n230
XU474 NOR2X1 $PINS A=A[9] B=B[9] Y=n237
XU475 NAND2BX1 $PINS AN=n127 B=n128 Y=n13
XU476 NOR2X2 $PINS A=B[12] B=A[12] Y=n224
XU477 NOR2X1 $PINS A=n78 B=n71 Y=n69
XU478 NOR2X2 $PINS A=A[10] B=B[10] Y=n403
XU479 XNOR2X2 $PINS A=n215 B=n23 Y=SUM[14]
XU480 NAND2BX1 $PINS AN=n403 B=n233 Y=n27
XU483 NAND2X1 $PINS A=B[12] B=A[12] Y=n225
XU484 AOI21X1 $PINS A0=n231 A1=n222 B0=n223 Y=n221
XU486 NAND2X1 $PINS A=n69 B=n49 Y=n47
XU487 XNOR2X1 $PINS A=n186 B=n20 Y=SUM[17]
XU488 INVX1 $PINS A=n134 Y=n431
XU491 NAND2X1 $PINS A=B[8] B=A[8] Y=n244
XU492 XNOR2X1 $PINS A=n53 B=n5 Y=SUM[32]
XU493 OAI21X2 $PINS A0=n229 A1=n227 B0=n228 Y=n226
XU494 NAND2XL $PINS A=n428 B=n107 Y=n101
XU495 INVX8 $PINS A=n219 Y=n449
XU496 OAI21XL $PINS A0=FE_OCPN6231_FE_OFN146_n150 A1=n43 B0=n44 Y=n42
XU497 AOI21X4 $PINS A0=n241 A1=n249 B0=n242 Y=n240
XU498 NOR2X1 $PINS A=n216 B=n213 Y=n211
XU499 OAI21XL $PINS A0=FE_OCPN6231_FE_OFN146_n150 A1=n63 B0=n64 Y=n62
XU500 AOI21X1 $PINS A0=n162 A1=n444 B0=n163 Y=n161
XU502 OAI21X1 $PINS A0=FE_OCPN6231_FE_OFN146_n150 A1=n429 B0=n426 Y=n80
XU503 NAND2X1 $PINS A=A[25] B=B[25] Y=n117
XU504 AOI21X1 $PINS A0=n151 A1=n219 B0=n152 Y=n150
XU505 NAND2BXL $PINS AN=n71 B=n72 Y=n7
XU506 OAI21XL $PINS A0=n71 A1=n79 B0=n72 Y=n70
XU507 NAND2X1 $PINS A=A[10] B=B[10] Y=n233
XU508 XNOR2X1 $PINS A=n168 B=n18 Y=SUM[19]
XU509 OAI21X1 $PINS A0=n403 A1=n238 B0=n233 Y=n231
XU510 NAND2X1 $PINS A=A[31] B=B[31] Y=n61
XU511 NOR2X1 $PINS A=A[13] B=B[13] Y=n216
XU512 NAND2X1 $PINS A=A[28] B=B[28] Y=n90
XU513 AOI21X1 $PINS A0=n94 A1=FE_DBTN181_n124 B0=n95 Y=n93
XU514 NAND2XL $PINS A=n431 B=n135 Y=n406
XU515 NAND2X1 $PINS A=A[22] B=B[22] Y=n146
XU516 NOR2X2 $PINS A=n123 B=n85 Y=n83
XU517 NOR2X2 $PINS A=n148 B=n145 Y=n143
XU519 NAND2X2 $PINS A=n143 B=n125 Y=n123
XU520 INVXL $PINS A=n117 Y=n432
XU521 NOR2X4 $PINS A=A[14] B=B[14] Y=n213
XU522 NOR2X1 $PINS A=A[32] B=B[32] Y=n51
XU523 NAND2XL $PINS A=A[33] B=B[33] Y=n41
XU524 INVX1 $PINS A=n47 Y=n423
XU525 INVX1 $PINS A=n143 Y=n427
XU526 INVX1 $PINS A=n185 Y=n441
XU527 OAI2BB1X1 $PINS A0N=n108 A1N=n435 B0=n99 Y=n95
XU528 INVXL $PINS A=n98 Y=n435
XU529 NAND2BX1 $PINS AN=n216 B=n460 Y=n24
XU530 NAND2BXL $PINS AN=n157 B=n158 Y=n17
XU531 NAND2BXL $PINS AN=n109 B=n110 Y=n11
XU532 NAND2BXL $PINS AN=n89 B=n90 Y=n9
XU533 INVX1 $PINS A=n48 Y=n422
XU534 INVX1 $PINS A=n79 Y=n437
XU535 NAND2X1 $PINS A=n439 B=n185 Y=n20
XU536 INVXL $PINS A=n107 Y=n434
XU537 OAI2BB1X1 $PINS A0N=n176 A1N=n442 B0=n167 Y=n163
XU538 INVXL $PINS A=n135 Y=n430
XU540 NAND2BXL $PINS AN=n227 B=n228 Y=n26
XU542 NAND2XL $PINS A=n83 B=n36 Y=n34
XU543 AOI21XL $PINS A0=n84 A1=n36 B0=n37 Y=n35
XU544 NAND2BX1 $PINS AN=n40 B=n41 Y=n4
XU545 NOR2X1 $PINS A=A[33] B=B[33] Y=n40
XU546 OR2XL $PINS A=A[5] B=B[5] Y=n400
XU335 XOR2X2 $PINS A=n118 B=n453 Y=SUM[25]
XU363 AND2X2 $PINS A=n433 B=n117 Y=n453
XU377 OR2X2 $PINS A=n109 B=n117 Y=n455
XU388 NAND2X1 $PINS A=n455 B=n110 Y=n108
XU404 OR2X2 $PINS A=n123 B=n116 Y=n112
XU436 OR2X2 $PINS A=n177 B=n185 Y=n457
XU485 NAND2X2 $PINS A=n457 B=n178 Y=n176
XU501 OAI2BB1X1 $PINS A0N=FE_OFN5652_n150 A1N=n459 B0=n55 Y=n53
XU547 AND2X2 $PINS A=n83 B=n56 Y=n459
XU548 NAND2X1 $PINS A=A[13] B=B[13] Y=n460
XU549 OAI2BB1X1 $PINS A0N=FE_OFN5652_n150 A1N=n462 B0=n93 Y=n91
XU551 AND2X2 $PINS A=n94 B=n428 Y=n462
XU552 XOR2X2 $PINS A=n147 B=n463 Y=SUM[22]
.ENDS

.SUBCKT CONV_DW_mult_uns_45 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[13] b[12]
+ b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0] product[33]
+ product[32] product[31] product[30] product[29] product[28] product[27]
+ product[26] product[25] product[24] product[23] product[22] product[21]
+ product[20] product[19] product[18] product[17] product[16] product[15]
+ product[14] product[13] product[12] product[11] product[10] product[9]
+ product[8] product[7] product[6] product[5] product[4] product[3] product[2]
+ product[1] product[0] n4973 p1 p2 p3 p4 p5 p6 p7 p8 p9 p10 p11 p12 p13 p14
+ p15 p16 p17 p18 p19 FE_OFN1_N1386 p20 p21 p22 FE_OFN63_register_6__19
+ FE_OFN90_register_6__17 FE_OFN5830_register_6__8
XFE_RC_632_0 OAI21X4 $PINS A0=n164 A1=n192 B0=n165 Y=n163
XFE_OFC1797_N872 INVXL $PINS A=n4973 Y=FE_OFN5887_N872
XFE_OFC1404_n135 INVX1 $PINS A=FE_DBTN179_n135 Y=FE_OFN5675_n135
XFE_OFC1403_n135 INVX1 $PINS A=n135 Y=FE_DBTN179_n135
XFE_OFC612_n136 CLKINVX3 $PINS A=n136 Y=FE_DBTN178_n136
XFE_OFC198_n557 INVX1 $PINS A=n557 Y=n177
XFE_DBTC177_n192 INVX2 $PINS A=n192 Y=FE_DBTN177_n192
XU436 AOI31X4 $PINS A0=FE_DBTN179_n135 A1=n499 A2=n163 B0=n77 Y=n1
XU519 CMPR42X1 $PINS A=p16 B=p13 C=n332 D=n336 ICI=n333 S=n330 ICO=n328 CO=n329
XU480 NAND2X1 $PINS A=n155 B=n137 Y=n135
XU505 AOI21X1 $PINS A0=n137 A1=n156 B0=n138 Y=n136
XU553 CMPR42X1 $PINS A=p15 B=p10 C=n341 D=n337 ICI=n338 S=n335 ICO=n333 CO=n334
XU569 NOR2X1 $PINS A=n320 B=n324 Y=n157
XU389 OAI21XL $PINS A0=n503 A1=n198 B0=n199 Y=n197
XU390 NAND2X1 $PINS A=n490 B=n560 Y=n492
XU391 NAND2X1 $PINS A=n492 B=n223 Y=n221
XU392 INVX1 $PINS A=n222 Y=n490
XU394 NOR2X1 $PINS A=n370 B=n373 Y=n222
XU396 OR2X2 $PINS A=n505 B=n142 Y=n493
XU397 NAND2X1 $PINS A=n493 B=n143 Y=n141
XU398 CLKINVX3 $PINS A=n163 Y=n505
XU399 XNOR2X1 $PINS A=n141 B=n14 Y=product[20]
XU401 XNOR2X1 $PINS A=n224 B=n27 Y=product[7]
XU402 OAI21XL $PINS A0=n501 A1=n225 B0=n226 Y=n224
XU403 OR2X2 $PINS A=n380 B=p22 Y=n484
XU404 ADDHXL $PINS A=p21 B=a[4] S=n380 CO=n379
XU405 NOR2X1 $PINS A=n248 B=a[2] Y=n246
XU406 ADDHXL $PINS A=p21 B=a[5] S=n376 CO=n375
XU407 ADDHXL $PINS A=a[5] B=a[8] S=n368 CO=n367
XU409 NAND2X1 $PINS A=n315 B=n319 Y=n147
XU410 NAND2X1 $PINS A=n325 B=n329 Y=n161
XU411 NAND2BXL $PINS AN=n195 B=n196 Y=n22
XU413 NAND2X1 $PINS A=n335 B=n339 Y=n176
XU414 NOR2X1 $PINS A=n330 B=n334 Y=n168
XU415 XOR2X1 $PINS A=n505 B=n17 Y=product[17]
XU416 XOR2X1 $PINS A=n235 B=n29 Y=product[5]
XU417 XOR2X1 $PINS A=n208 B=n24 Y=product[10]
XU418 AOI21X1 $PINS A0=n80 A1=n120 B0=n81 Y=n79
XU419 NAND2BX1 $PINS AN=n4973 B=FE_OFN1_N1386 Y=n248
XU420 XNOR2X1 $PINS A=n148 B=n15 Y=product[19]
XU421 NOR2X1 $PINS A=n168 B=n175 Y=n166
XU422 XOR3X2 $PINS A=n283 B=n282 C=n54 Y=product[29]
XU423 NOR2XL $PINS A=p2 B=p4 Y=n487
XU424 OAI2BB1X1 $PINS A0N=n499 A1N=FE_DBTN178_n136 B0=n79 Y=n77
XU426 AND2X1 $PINS A=n380 B=p22 Y=n506
XU427 OAI21X2 $PINS A0=n525 A1=n229 B0=n230 Y=n228
XU428 INVX1 $PINS A=n475 Y=n525
XU429 OAI21XL $PINS A0=n157 A1=n161 B0=n158 Y=n156
XU432 NAND2BXL $PINS AN=n198 B=n199 Y=n23
XU433 AOI21X1 $PINS A0=n502 A1=n209 B0=n210 Y=n208
XU435 AOI21X1 $PINS A0=n163 A1=n155 B0=n156 Y=n496
XU437 INVX1 $PINS A=n496 Y=n148
XU438 OAI21XL $PINS A0=n184 A1=n190 B0=n185 Y=n183
XU439 NAND2X1 $PINS A=n362 B=n365 Y=n212
XU440 NAND2X1 $PINS A=n519 B=n486 Y=n93
XU441 AOI21X1 $PINS A0=FE_DBTN177_n192 A1=n171 B0=n172 Y=n170
XU443 NAND2X1 $PINS A=FE_DBTN179_n135 B=n514 Y=n124
XU444 AOI21X1 $PINS A0=n475 A1=n484 B0=n506 Y=n235
XU446 XOR3X2 $PINS A=n228 B=n374 C=n377 Y=product[6]
XU448 NAND2X1 $PINS A=n366 B=n369 Y=n217
XU450 OR2X2 $PINS A=n378 B=n379 Y=n488
XU451 AOI21X1 $PINS A0=FE_DBTN178_n136 A1=n514 B0=n517 Y=n125
XU453 INVXL $PINS A=n129 Y=n517
XU454 XOR2X1 $PINS A=n213 B=n25 Y=product[9]
XU455 NOR2X1 $PINS A=n516 B=n93 Y=n91
XU456 INVX1 $PINS A=n119 Y=n516
XU457 NOR2BX1 $PINS AN=n71 B=n70 Y=n500
XU458 AND2X2 $PINS A=n119 B=n80 Y=n499
XU459 XNOR2X1 $PINS A=n197 B=n22 Y=product[12]
XU460 XOR3X2 $PINS A=n475 B=n380 C=p22 Y=product[4]
XU461 XNOR2X1 $PINS A=n88 B=n9 Y=product[25]
XU465 INVX1 $PINS A=n207 Y=n534
XU466 OAI21XL $PINS A0=n211 A1=n217 B0=n212 Y=n210
XU467 ADDHXL $PINS A=FE_OFN5887_N872 B=a[11] S=n357 CO=n356
XU469 ADDFX2 $PINS A=p11 B=p15 CI=n293 S=n290 CO=n289
XU471 NOR2X1 $PINS A=n315 B=n319 Y=n146
XU472 NOR2X1 $PINS A=n552 B=n146 Y=n137
XU473 ADDFX2 $PINS A=a[0] B=a[4] CI=a[11] S=n342 CO=n341
XU475 CMPR22X1 $PINS A=a[4] B=p9 S=n364 CO=n363
XU476 ADDFX2 $PINS A=p2 B=a[11] CI=a[6] S=n332 CO=n331
XU477 ADDFX2 $PINS A=p4 B=a[18] CI=a[8] S=n322 CO=n321
XU478 ADDFX2 $PINS A=p5 B=p9 CI=p16 S=n317 CO=n316
XU481 CMPR42X1 $PINS A=a[8] B=a[6] C=p10 D=n357 ICI=n358 S=n355 ICO=n353
+ CO=n354
XU482 ADDFX2 $PINS A=p22 B=n487 CI=n368 S=n366 CO=n365
XU484 OAI21XL $PINS A0=n168 A1=n176 B0=n169 Y=n167
XU485 CMPR42X1 $PINS A=p14 B=p12 C=n331 D=n327 ICI=n328 S=n325 ICO=n323 CO=n324
XU486 CMPR42X1 $PINS A=p19 B=p14 C=n321 D=n317 ICI=n318 S=n315 ICO=n313 CO=n314
XU487 NOR2X1 $PINS A=n309 B=n305 Y=n128
XU488 NAND2X1 $PINS A=n355 B=n359 Y=n199
XU489 NOR2X1 $PINS A=n355 B=n359 Y=n198
XU490 INVX1 $PINS A=n219 Y=n502
XU491 XOR2X1 $PINS A=n170 B=n18 Y=product[16]
XU492 NOR2X1 $PINS A=n325 B=n329 Y=n160
XU493 NAND2X1 $PINS A=n309 B=n305 Y=n129
XU494 NOR2X1 $PINS A=n128 B=n121 Y=n119
XU495 INVX1 $PINS A=n110 Y=n519
XU496 INVX1 $PINS A=n128 Y=n514
XU497 NOR2X1 $PINS A=n300 B=n304 Y=n121
XU498 OAI21XL $PINS A0=n518 A1=n110 B0=n111 Y=n105
XU499 XOR2X1 $PINS A=n186 B=n20 Y=product[14]
XU500 XNOR2X1 $PINS A=FE_DBTN177_n192 B=n497 Y=product[13]
XU501 OR2X2 $PINS A=p1 B=p3 Y=n483
XU502 NAND2X1 $PINS A=p1 B=p3 Y=n245
XU503 OAI21XL $PINS A0=n1 A1=n55 B0=n56 Y=n54
XU504 XNOR2X1 $PINS A=n61 B=n6 Y=product[28]
XU506 OAI21XL $PINS A0=n1 A1=n529 B0=n527 Y=n61
XU507 INVX1 $PINS A=n91 Y=n515
XU508 OAI21XL $PINS A0=n1 A1=n73 B0=n74 Y=n72
XU509 AOI21X1 $PINS A0=n502 A1=n508 B0=n507 Y=n213
XU510 NAND2X1 $PINS A=n508 B=n217 Y=n26
XU515 OAI21X1 $PINS A0=n202 A1=n219 B0=n203 Y=n201
XU516 NAND2X1 $PINS A=n482 B=n209 Y=n202
XU517 AOI21X1 $PINS A0=n482 A1=n210 B0=n534 Y=n203
XU518 AOI21X4 $PINS A0=n220 A1=n228 B0=n221 Y=n219
XU521 CMPR42X1 $PINS A=p9 B=p14 C=n346 D=n342 ICI=n343 S=n340 ICO=n338 CO=n339
XU522 CMPR42X1 $PINS A=a[9] B=a[18] C=p13 D=n301 ICI=n298 S=n297 ICO=n295
+ CO=n296
XU523 XNOR2X1 $PINS A=a[14] B=a[18] Y=n284
XU525 AOI21X1 $PINS A0=n166 A1=n183 B0=n167 Y=n165
XU526 AOI21X2 $PINS A0=n201 A1=n193 B0=n194 Y=n192
XU527 ADDFX2 $PINS A=a[6] B=p22 CI=n376 S=n374 CO=n373
XU529 INVX1 $PINS A=n120 Y=n518
XU530 NAND2X1 $PINS A=n554 B=n166 Y=n164
XU531 OAI21XL $PINS A0=n552 A1=n147 B0=n140 Y=n138
XU533 OAI221XL $PINS A0=n518 A1=n93 B0=n521 B1=n111 C0=n100 Y=n92
XU534 OAI21XL $PINS A0=n74 A1=n70 B0=n71 Y=n69
XU535 XNOR2X1 $PINS A=n130 B=n13 Y=product[21]
XU536 NAND2BX1 $PINS AN=n552 B=n140 Y=n14
XU537 NAND2XL $PINS A=n155 B=n512 Y=n142
XU539 ADDFX2 $PINS A=n4973 B=a[5] CI=p12 S=n337 CO=n336
XU540 ADDFX2 $PINS A=p17 B=p3 CI=p7 S=n327 CO=n326
XU541 CMPR42X1 $PINS A=p13 B=p10 C=n351 D=n347 ICI=n348 S=n345 ICO=n343 CO=n344
XU542 CMPR42X1 $PINS A=p12 B=p7 C=n352 D=n356 ICI=n353 S=n350 ICO=n348 CO=n349
XU543 NOR2X1 $PINS A=n345 B=n349 Y=n189
XU544 ADDFX2 $PINS A=p7 B=n372 CI=n375 S=n370 CO=n369
XU545 ADDFX2 $PINS A=a[6] B=n364 CI=n367 S=n362 CO=n361
XU546 NOR2X1 $PINS A=n222 B=n225 Y=n220
XU547 NOR2X1 $PINS A=n366 B=n369 Y=n216
XU548 NAND2X1 $PINS A=n486 B=n481 Y=n82
XU549 NOR2X1 $PINS A=n198 B=n195 Y=n193
XU550 OAI21XL $PINS A0=n195 A1=n199 B0=n196 Y=n194
XU551 NAND2X1 $PINS A=n330 B=n334 Y=n169
XU552 NOR2X1 $PINS A=n335 B=n339 Y=n175
XU555 CMPR42X1 $PINS A=p15 B=p13 C=n326 D=n322 ICI=n323 S=n320 ICO=n318 CO=n319
XU556 CMPR42X1 $PINS A=p15 B=p10 C=n312 D=n316 ICI=n313 S=n310 ICO=n308 CO=n309
XU557 NAND2X1 $PINS A=n340 B=n344 Y=n185
XU558 NOR2X1 $PINS A=n340 B=n344 Y=n184
XU559 NOR2X1 $PINS A=n350 B=n354 Y=n195
XU560 INVX1 $PINS A=n201 Y=n503
XU561 NAND2X1 $PINS A=n345 B=n349 Y=n190
XU562 NOR2X1 $PINS A=n374 B=n377 Y=n225
XU563 NOR2X1 $PINS A=n211 B=n216 Y=n209
XU564 INVX1 $PINS A=n216 Y=n508
XU565 NOR2X1 $PINS A=n82 B=n110 Y=n80
XU567 NAND2X1 $PINS A=n310 B=n314 Y=n140
XU568 XNOR2X1 $PINS A=n47 B=n4 Y=product[30]
XU570 XNOR2X1 $PINS A=n123 B=n12 Y=product[22]
XU571 XNOR2X1 $PINS A=n112 B=n11 Y=product[23]
XU572 OAI31X1 $PINS A0=n505 A1=FE_OFN5675_n135 A2=n516 B0=n114 Y=n112
XU573 XNOR2X1 $PINS A=n101 B=n10 Y=product[24]
XU574 XOR2X1 $PINS A=n1 B=n8 Y=product[26]
XU575 XNOR2X1 $PINS A=n246 B=n31 Y=product[3]
XU576 XOR2X1 $PINS A=n72 B=n500 Y=product[27]
XU577 XOR2X1 $PINS A=n177 B=n19 Y=product[15]
XU579 XOR2X1 $PINS A=n503 B=n23 Y=product[11]
XU580 XNOR2X1 $PINS A=n159 B=n16 Y=product[18]
XU581 OAI21XL $PINS A0=n505 A1=n160 B0=n161 Y=n159
XU582 XOR2X1 $PINS A=p20 B=a[4] Y=n372
XU583 XNOR2XL $PINS A=a[13] B=p17 Y=n286
XU584 NAND2BX1 $PINS AN=n222 B=n223 Y=n27
XU585 NAND2X1 $PINS A=n373 B=n370 Y=n223
XU586 OAI2BB1X1 $PINS A0N=n246 A1N=n483 B0=n245 Y=n475
XU587 AOI21X1 $PINS A0=FE_DBTN177_n192 A1=n523 B0=n522 Y=n186
XU588 AOI21X1 $PINS A0=n488 A1=n506 B0=n540 Y=n230
XU589 XNOR2X1 $PINS A=n4973 B=FE_OFN1_N1386 Y=product[1]
XU590 ADDFX2 $PINS A=p5 B=p1 CI=p20 S=n378 CO=n377
XU593 NOR2X1 $PINS A=n157 B=n160 Y=n155
XU594 NOR2X1 $PINS A=n362 B=n365 Y=n211
XU595 AOI21XL $PINS A0=FE_DBTN178_n136 A1=n119 B0=n120 Y=n114
XU596 INVXL $PINS A=n69 Y=n527
XU597 NOR2XL $PINS A=n73 B=n70 Y=n68
XU598 AOI21XL $PINS A0=n156 A1=n512 B0=n513 Y=n143
XU599 INVXL $PINS A=n147 Y=n513
XU600 INVXL $PINS A=n146 Y=n512
XU601 NAND2BXL $PINS AN=n121 B=n122 Y=n12
XU602 OAI21XL $PINS A0=n124 A1=n505 B0=n125 Y=n123
XU603 NAND2XL $PINS A=n519 B=n111 Y=n11
XU604 NAND2BX1 $PINS AN=n73 B=n74 Y=n8
XU605 INVXL $PINS A=n59 Y=n530
XU606 NAND2XL $PINS A=n284 B=n285 Y=n60
XU608 NAND2XL $PINS A=n523 B=n190 Y=n497
XU609 INVXL $PINS A=n189 Y=n523
XU610 NAND2XL $PINS A=n68 B=n50 Y=n48
XU611 INVXL $PINS A=n228 Y=n501
XU612 NAND2XL $PINS A=n488 B=n234 Y=n29
XU613 NAND2XL $PINS A=n482 B=n207 Y=n24
XU615 AOI21X1 $PINS A0=FE_DBTN178_n136 A1=n104 B0=n105 Y=n103
XU616 AOI21X1 $PINS A0=FE_DBTN178_n136 A1=n91 B0=n92 Y=n90
XU617 INVXL $PINS A=n486 Y=n521
XU618 NAND2XL $PINS A=n483 B=n245 Y=n31
XU619 NAND2X1 $PINS A=n360 B=n361 Y=n207
XU620 NAND2XL $PINS A=n300 B=n304 Y=n122
XU621 AOI22XL $PINS A0=n284 A1=n285 B0=n530 B1=n69 Y=n56
XU622 NAND2XL $PINS A=n282 B=n283 Y=n53
XU623 NAND2XL $PINS A=n286 B=n287 Y=n71
XU624 XNOR2X1 $PINS A=FE_OFN5830_register_6__8 B=p17 Y=n302
XU625 XNOR2X1 $PINS A=p6 B=p17 Y=n312
XU626 XOR2XL $PINS A=n498 B=a[19] Y=product[33]
XU627 NOR2XL $PINS A=n35 B=p18 Y=n498
XU628 NAND2BXL $PINS AN=n160 B=n161 Y=n17
XU629 XNOR2X1 $PINS A=n502 B=n26 Y=product[8]
XU630 NAND2BXL $PINS AN=n175 B=n176 Y=n19
XU631 NAND2BXL $PINS AN=n184 B=n185 Y=n20
XU632 INVXL $PINS A=n190 Y=n522
XU633 NAND2BX1 $PINS AN=n211 B=n212 Y=n25
XU634 INVX1 $PINS A=n217 Y=n507
XU635 NAND2BXL $PINS AN=n168 B=n169 Y=n18
XU636 NOR2BX1 $PINS AN=n554 B=n175 Y=n171
XU637 NAND2BXL $PINS AN=n157 B=n158 Y=n16
XU638 NAND2XL $PINS A=n512 B=n147 Y=n15
XU639 INVX1 $PINS A=n68 Y=n529
XU640 NAND2X1 $PINS A=n320 B=n324 Y=n158
XU641 NAND2X1 $PINS A=n350 B=n354 Y=n196
XU642 NAND2X1 $PINS A=n514 B=n129 Y=n13
XU643 NAND2X1 $PINS A=n488 B=n484 Y=n229
XU644 INVX1 $PINS A=n234 Y=n540
XU645 OAI21XL $PINS A0=n121 A1=n129 B0=n122 Y=n120
XU646 NOR2XL $PINS A=n516 B=n110 Y=n104
XU647 OAI221XL $PINS A0=n520 A1=n100 B0=n82 B1=n111 C0=n87 Y=n81
XU648 INVX1 $PINS A=n481 Y=n520
XU649 NAND2X1 $PINS A=n530 B=n60 Y=n6
XU650 NAND2X1 $PINS A=n68 B=n530 Y=n55
XU651 NAND2X1 $PINS A=n486 B=n100 Y=n10
XU652 NAND2X1 $PINS A=n481 B=n87 Y=n9
XU653 OAI31XL $PINS A0=n515 A1=n505 A2=FE_OFN5675_n135 B0=n90 Y=n88
XU654 AOI21X1 $PINS A0=n50 A1=n69 B0=n51 Y=n49
XU655 OAI21XL $PINS A0=n52 A1=n60 B0=n53 Y=n51
XU656 NOR2X1 $PINS A=n52 B=n59 Y=n50
XU657 OR2X2 $PINS A=n360 B=n361 Y=n482
XU658 NAND2X1 $PINS A=n378 B=n379 Y=n234
XU659 NOR2X1 $PINS A=n299 B=n297 Y=n110
XU660 NAND2X1 $PINS A=n299 B=n297 Y=n111
XU661 OR2X2 $PINS A=n296 B=n292 Y=n486
XU662 NAND2X1 $PINS A=n296 B=n292 Y=n100
XU663 OR2X2 $PINS A=n291 B=n290 Y=n481
XU664 NAND2X1 $PINS A=n291 B=n290 Y=n87
XU665 NAND2BX1 $PINS AN=n45 B=n46 Y=n4
XU666 OAI21XL $PINS A0=n1 A1=n48 B0=n49 Y=n47
XU667 NOR2X1 $PINS A=n286 B=n287 Y=n70
XU668 NOR2X1 $PINS A=n282 B=n283 Y=n52
XU669 NOR2X1 $PINS A=n289 B=n288 Y=n73
XU670 OAI21XL $PINS A0=n49 A1=n45 B0=n46 Y=n44
XU671 NAND2X1 $PINS A=n289 B=n288 Y=n74
XU672 NOR2X1 $PINS A=n284 B=n285 Y=n59
XU673 OR2X2 $PINS A=n48 B=n45 Y=n485
XU674 CMPR42X1 $PINS A=a[10] B=p1 C=a[5] D=p7 ICI=n363 S=n360 ICO=n358 CO=n359
XU675 CMPR42X1 $PINS A=p19 B=p12 C=n306 D=n302 ICI=n303 S=n300 ICO=n298 CO=n299
XU676 OR2XL $PINS A=a[7] B=a[18] Y=n306
XU677 OAI21XL $PINS A0=n1 A1=n485 B0=n37 Y=n35
XU678 NOR2XL $PINS A=n44 B=a[17] Y=n37
XU679 OR2XL $PINS A=a[10] B=p19 Y=n293
XU680 ADDFX2 $PINS A=p14 B=n295 CI=n294 S=n292 CO=n291
XU681 XNOR2X1 $PINS A=a[10] B=p19 Y=n294
XU682 XOR2XL $PINS A=n248 B=a[2] Y=product[2]
XU683 XNOR2XL $PINS A=n40 B=a[17] Y=product[31]
XU684 OAI21XL $PINS A0=n1 A1=n485 B0=n528 Y=n40
XU685 INVX1 $PINS A=n44 Y=n528
XU686 XNOR2XL $PINS A=n35 B=p18 Y=product[32]
XU687 OR2XL $PINS A=FE_OFN5830_register_6__8 B=p17 Y=n301
XU688 CMPR42X1 $PINS A=a[11] B=p16 C=n311 D=n307 ICI=n308 S=n305 ICO=n303
+ CO=n304
XU689 XNOR2X1 $PINS A=a[7] B=a[18] Y=n307
XU690 OR2XL $PINS A=p6 B=p17 Y=n311
XU691 OR2XL $PINS A=a[13] B=p17 Y=n285
XU692 XNOR2XL $PINS A=p19 B=a[15] Y=n282
XU693 XNOR2XL $PINS A=p16 B=a[12] Y=n288
XU694 OR2XL $PINS A=p16 B=a[12] Y=n287
XU695 NOR2XL $PINS A=n281 B=a[16] Y=n45
XU696 NAND2XL $PINS A=n281 B=a[16] Y=n46
XU697 OR2XL $PINS A=FE_OFN63_register_6__19 B=a[15] Y=n281
XU698 OR2XL $PINS A=a[14] B=a[18] Y=n283
XU395 NOR2X1 $PINS A=n310 B=n314 Y=n552
XU430 OAI2BB1X1 $PINS A0N=n163 A1N=n553 B0=n103 Y=n101
XU431 AND2X2 $PINS A=FE_DBTN179_n135 B=n104 Y=n553
XU434 NOR2X1 $PINS A=n184 B=n189 Y=n554
XU445 OAI2BB1X1 $PINS A0N=n183 A1N=n555 B0=n176 Y=n172
XU449 INVX1 $PINS A=n175 Y=n555
XU464 OAI2BB1X1 $PINS A0N=n163 A1N=FE_DBTN179_n135 B0=n136 Y=n130
XU538 OAI2BB1X1 $PINS A0N=FE_DBTN177_n192 A1N=n554 B0=n558 Y=n557
XU699 INVX1 $PINS A=n183 Y=n558
XU701 AND2X2 $PINS A=n374 B=n377 Y=n560
XU702 INVX1 $PINS A=n560 Y=n226
XU703 XOR2X1 $PINS A=p20 B=p9 Y=n352
XU704 INVX1 $PINS A=n561 Y=n351
XU705 NAND2X1 $PINS A=p20 B=p9 Y=n561
XU708 XOR2X1 $PINS A=a[8] B=p22 Y=n347
XU709 INVX1 $PINS A=n564 Y=n346
XU710 NAND2X1 $PINS A=a[8] B=p22 Y=n564
.ENDS

.SUBCKT CONV_DW_mult_uns_46 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[14] b[13]
+ b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0]
+ product[34] product[33] product[32] product[31] product[30] product[29]
+ product[28] product[27] product[26] product[25] product[24] product[23]
+ product[22] product[21] product[20] product[19] product[18] product[17]
+ product[16] product[15] product[14] product[13] product[12] product[11]
+ product[10] product[9] product[8] product[7] product[6] product[5] product[4]
+ product[3] product[2] product[1] product[0] p1 p2 p3 p4 p5 p6 p7 p8 p9 p10
+ p11 p12 p13 p14 p15 p16 p17 p18 p19 p20 FE_OFN5_register_8__12
+ FE_OFN8_register_8__15 FE_OFN9_register_8__3 FE_OFN15_register_8__9
+ FE_OFN19_N1034 FE_OFN17_N1034 FE_OFN21_register_8__14 FE_OFN23_register_8__16
+ FE_OFN28_register_8__17 FE_OFN39_register_8__19 FE_OFN47_register_8__18
+ FE_OFN52_register_8__12 _register_8_6 p21 p22 p23 p24 FE_OFN61_n5323
+ FE_OFN68_register_8__7 FE_OFN69_register_8__2 FE_OFN85_N1424
+ FE_OFN86_register_8__16 FE_OFN89_register_8__15 FE_OFN91_register_8__3
+ FE_OFN95_n FE_OFN101_n
XFE_RC_660_0 NAND2BX2 $PINS AN=n566 B=FE_OFN5924_n869 Y=FE_RN_356_0
XFE_RC_659_0 OAI211X2 $PINS A0=n867 A1=n866 B0=FE_RN_356_0 C0=n868 Y=n846
XFE_RC_513_0 INVX1 $PINS A=n643 Y=FE_RN_283_0
XFE_RC_512_0 MXI2X2 $PINS S0=n642 B=n643 A=FE_RN_283_0 Y=product[27]
XFE_OFC1876_n869 INVX1 $PINS A=FE_DBTN176_n869 Y=FE_OFN5924_n869
XFE_OFC1875_n869 INVX1 $PINS A=n869 Y=FE_DBTN176_n869
XFE_OFC1674_n918 INVX1 $PINS A=n918 Y=n568
XFE_OFC1620_register_8__9 INVX1 $PINS A=a[9] Y=FE_OFN5792_register_8__9
XFE_OFC1577_register_8__7 INVX1 $PINS A=p8 Y=FE_OFN5770_register_8__7
XFE_OFC1505_N999 INVXL $PINS A=a[0] Y=FE_OFN5729_N999
XFE_OFC1478_register_8__13 INVX1 $PINS A=p14 Y=FE_OFN5716_register_8__13
XFE_OFC1469_register_8__15 INVX1 $PINS A=a[15] Y=FE_RN_2
XU406 AOI21X2 $PINS A0=n590 A1=n591 B0=n592 Y=n584
XU407 AOI2BB1XL $PINS A0N=n591 A1N=n590 B0=FE_OFN86_register_8__16 Y=n592
XU426 AOI221X2 $PINS A0=n615 A1=n616 B0=n745 B1=n740 C0=n617 Y=n606
XU428 NAND3X1 $PINS A=n761 B=n749 C=n615 Y=n612
XU451 NOR2X2 $PINS A=n644 B=n645 Y=n640
XU452 AND2X2 $PINS A=n645 B=n644 Y=n618
XU453 OAI21XL $PINS A0=n646 A1=n647 B0=n648 Y=n644
XU454 OAI2BB1X1 $PINS A0N=n647 A1N=n646 B0=n649 Y=n648
XU459 NAND2X2 $PINS A=n601 B=n607 Y=n614
XU467 NOR2X1 $PINS A=n655 B=n666 Y=n662
XU468 OAI21XL $PINS A0=n661 A1=n659 B0=n679 Y=n655
XU480 XNOR2X4 $PINS A=n678 B=n661 Y=product[25]
XU494 AOI31X1 $PINS A0=n679 A1=n693 A2=n654 B0=n660 Y=n692
XU519 NOR2BX4 $PINS AN=n665 B=n564 Y=n693
XU561 OAI2BB1X2 $PINS A0N=n751 A1N=n750 B0=n753 Y=n752
XU575 AND2X2 $PINS A=n610 B=n763 Y=n741
XU585 AOI21X4 $PINS A0=n773 A1=n774 B0=n775 Y=n772
XU598 AND2X2 $PINS A=n622 B=n787 Y=n757
XU622 NAND3X2 $PINS A=n804 B=n803 C=n575 Y=n773
XU648 AND2X2 $PINS A=n826 B=n827 Y=n805
XU667 OAI211X2 $PINS A0=n844 A1=n845 B0=n846 C0=n847 Y=n843
XU393 INVX1 $PINS A=n848 Y=n593
XU394 AOI21X1 $PINS A0=n536 A1=n575 B0=n805 Y=n808
XU395 OAI2BB1X1 $PINS A0N=n728 A1N=n727 B0=n730 Y=n729
XU396 XNOR3X2 $PINS A=n718 B=n717 C=n712 Y=product[23]
XU397 OAI2BB1X1 $PINS A0N=n719 A1N=n720 B0=n721 Y=n717
XU399 OAI21XL $PINS A0=FE_OFN5924_n869 A1=n870 B0=n871 Y=n868
XU400 NAND2X1 $PINS A=n922 B=n923 Y=n919
XU401 OAI2BB1X1 $PINS A0N=n930 A1N=n929 B0=FE_OFN85_N1424 Y=n931
XU402 XOR2X1 $PINS A=n883 B=n885 Y=n516
XU403 XOR2X1 $PINS A=n882 B=n516 Y=n869
XU404 INVX1 $PINS A=n690 Y=n679
XU410 INVX1 $PINS A=n518 Y=n523
XU411 OAI21XL $PINS A0=n707 A1=n708 B0=n709 Y=n697
XU412 OAI2BB1X1 $PINS A0N=n847 A1N=n846 B0=n593 Y=n850
XU413 OAI21XL $PINS A0=FE_OFN52_register_8__12 A1=p19 B0=n747 Y=n730
XU414 NOR2X2 $PINS A=n927 B=n928 Y=n918
XU415 NOR2X1 $PINS A=p8 B=p1 Y=n879
XU416 XNOR2X1 $PINS A=FE_OFN61_n5323 B=a[11] Y=n878
XU417 NOR2X1 $PINS A=n902 B=n903 Y=n892
XU419 NOR2X1 $PINS A=n770 B=n771 Y=n775
XU421 OAI21XL $PINS A0=n929 A1=n930 B0=n931 Y=n927
XU422 OAI2BB1X1 $PINS A0N=FE_OFN95_n A1N=FE_OFN68_register_8__7 B0=n909 Y=n891
XU425 OAI21XL $PINS A0=n852 A1=n851 B0=n854 Y=n853
XU427 OAI2BB1X1 $PINS A0N=n814 A1N=n813 B0=n816 Y=n815
XU429 INVX1 $PINS A=n844 Y=n569
XU430 XOR2X1 $PINS A=n946 B=n930 Y=n922
XU431 NAND2X1 $PINS A=n754 B=n755 Y=n714
XU432 NOR2X1 $PINS A=n697 B=n696 Y=n690
XU433 OAI21XL $PINS A0=n567 A1=n866 B0=n566 Y=n887
XU434 NAND2X1 $PINS A=n607 B=n603 Y=n613
XU435 XOR2X2 $PINS A=n620 B=n621 Y=product[29]
XU437 NOR2X2 $PINS A=n693 B=n534 Y=n712
XU438 OAI21XL $PINS A0=n879 A1=n878 B0=p23 Y=n880
XU439 OAI2BB1X1 $PINS A0N=n882 A1N=n883 B0=n884 Y=n518
XU440 XOR2X1 $PINS A=FE_OFN5716_register_8__13 B=n864 Y=n831
XU441 OAI2BB1X1 $PINS A0N=a[4] A1N=a[14] B0=n820 Y=n799
XU442 XOR2X1 $PINS A=n833 B=n830 Y=n549
XU443 OAI21XL $PINS A0=FE_OFN5_register_8__12 A1=a[11] B0=n819 Y=n796
XU444 XNOR2X1 $PINS A=FE_OFN19_N1034 B=n818 Y=n883
XU445 OAI21XL $PINS A0=FE_OFN5716_register_8__13 A1=FE_OFN91_register_8__3
+ B0=p8 Y=n836
XU446 XOR2X1 $PINS A=p11 B=n835 Y=n889
XU447 XNOR2X1 $PINS A=p8 B=p18 Y=n786
XU448 OAI21X1 $PINS A0=a[6] A1=a[5] B0=n913 Y=n904
XU450 OAI21XL $PINS A0=p1 A1=p6 B0=n876 Y=n854
XU455 OAI21XL $PINS A0=p22 A1=n651 B0=n652 Y=n781
XU457 AOI2BB1X1 $PINS A0N=FE_OFN8_register_8__15 A1N=p17 B0=n748 Y=n727
XU461 INVX1 $PINS A=n870 Y=n566
XU462 OAI21XL $PINS A0=a[5] A1=FE_RN_2 B0=n801 Y=n784
XU463 XNOR2X1 $PINS A=p8 B=FE_OFN91_register_8__3 Y=n864
XU464 NOR2X1 $PINS A=n716 B=n713 Y=n665
XU465 XNOR3X2 $PINS A=n703 B=n706 C=n704 Y=n707
XU466 XOR2X1 $PINS A=a[4] B=_register_8_6 Y=n944
XU469 XOR3X2 $PINS A=n744 B=n741 C=n742 Y=n736
XU470 OAI22X1 $PINS A0=n895 A1=n896 B0=n902 B1=n903 Y=n866
XU471 XOR3X2 $PINS A=n634 B=n635 C=n632 Y=product[28]
XU472 XNOR3X2 $PINS A=n856 B=n858 C=n859 Y=n851
XU473 NOR2BX1 $PINS AN=n837 B=n671 Y=n813
XU474 XNOR3X2 $PINS A=FE_OFN23_register_8__16 B=a[8] C=p18 Y=n719
XU475 OAI21XL $PINS A0=p4 A1=n904 B0=n906 Y=n905
XU476 AND2X2 $PINS A=a[2] B=p2 Y=n863
XU477 OAI2BB1X1 $PINS A0N=p18 A1N=FE_OFN23_register_8__16 B0=n726 Y=n703
XU478 XNOR3X2 $PINS A=n904 B=n864 C=n907 Y=n895
XU479 AOI2BB1X1 $PINS A0N=n713 A1N=n714 B0=n519 Y=n639
XU481 INVX1 $PINS A=n715 Y=n519
XU482 NOR2X1 $PINS A=n827 B=n826 Y=n809
XU483 XOR3X2 $PINS A=n720 B=n722 C=n719 Y=n734
XU484 NAND2X1 $PINS A=n895 B=n896 Y=n893
XU485 XNOR3X2 $PINS A=FE_OFN17_N1034 B=FE_OFN91_register_8__3 C=n944 Y=n571
XU486 OAI211X1 $PINS A0=n623 A1=n622 B0=n626 C0=n625 Y=n615
XU487 XOR3X2 $PINS A=p11 B=FE_OFN95_n C=FE_OFN23_register_8__16 Y=n782
XU488 XOR3X2 $PINS A=n622 B=p20 C=n623 Y=n635
XU489 XOR3X2 $PINS A=n792 B=n794 C=n791 Y=n810
XU490 XNOR3X2 $PINS A=n688 B=n689 C=n686 Y=n696
XU491 OAI21XL $PINS A0=p4 A1=p3 B0=n937 Y=n572
XU493 XOR3X2 $PINS A=n536 B=n827 C=n826 Y=product[17]
XU495 XOR3X2 $PINS A=n736 B=n738 C=n735 Y=n754
XU496 XOR3X2 $PINS A=FE_OFN5924_n869 B=n887 C=n871 Y=product[14]
XU497 XOR3X2 $PINS A=n727 B=n730 C=n728 Y=n720
XU498 XNOR3X2 $PINS A=n682 B=n684 C=n681 Y=n686
XU499 XOR3X2 $PINS A=n844 B=n850 C=n845 Y=product[16]
XU500 OAI2BB1X4 $PINS A0N=n520 A1N=n526 B0=n752 Y=n664
XU501 INVX1 $PINS A=n751 Y=n520
XU502 INVX1 $PINS A=n750 Y=n526
XU503 XNOR2X1 $PINS A=n896 B=n895 Y=n911
XU504 OAI21XL $PINS A0=n637 A1=n636 B0=p19 Y=n638
XU506 AND3X1 $PINS A=n604 B=n607 C=n745 Y=n602
XU507 INVX1 $PINS A=n612 Y=n745
XU508 XOR3X2 $PINS A=n822 B=n824 C=n821 Y=n826
XU509 XOR2X1 $PINS A=n891 B=n889 Y=n544
XU511 NAND2XL $PINS A=n593 B=n847 Y=n865
XU512 XOR2X1 $PINS A=n710 B=n708 Y=n723
XU513 NOR2X1 $PINS A=n733 B=n734 Y=n713
XU514 XOR3X2 $PINS A=n755 B=n754 C=n664 Y=product[21]
XU515 XNOR3X2 $PINS A=n914 B=n881 C=n917 Y=n928
XU516 OAI2BB1X1 $PINS A0N=n840 A1N=n600 B0=n839 Y=n827
XU517 INVX1 $PINS A=n838 Y=n600
XU518 XNOR2X1 $PINS A=n922 B=n923 Y=n935
XU520 OAI2BB1X1 $PINS A0N=n534 A1N=n654 B0=n656 Y=n527
XU521 INVXL $PINS A=n666 Y=n654
XU522 XOR3X2 $PINS A=p18 B=n565 C=n605 Y=product[30]
XU523 XNOR3X2 $PINS A=n751 B=n753 C=n526 Y=product[20]
XU524 OAI21XL $PINS A0=n587 A1=n858 B0=n859 Y=n857
XU525 INVX1 $PINS A=n856 Y=n587
XU526 OAI2BB2X1 $PINS A0N=n903 A1N=n902 B0=n892 B1=n893 Y=n870
XU527 XOR3X2 $PINS A=a[4] B=p8 C=p6 Y=n930
XU528 OAI2BB1X1 $PINS A0N=n708 A1N=n707 B0=n710 Y=n709
XU529 XNOR3X2 $PINS A=n766 B=n768 C=n765 Y=n751
XU530 XOR2XL $PINS A=a[2] B=FE_OFN5729_N999 Y=product[5]
XU531 INVX1 $PINS A=n639 Y=n534
XU532 NOR2BX1 $PINS AN=FE_OFN47_register_8__18 B=p20 Y=n589
XU533 XOR3X2 $PINS A=n789 B=n771 C=n770 Y=product[19]
XU534 XOR3X2 $PINS A=n813 B=n816 C=n814 Y=n822
XU535 OAI21XL $PINS A0=n757 A1=n758 B0=n759 Y=n738
XU536 XNOR3X2 $PINS A=n838 B=n841 C=n840 Y=n844
XU537 AND2X2 $PINS A=n696 B=n697 Y=n660
XU538 XNOR3X2 $PINS A=n574 B=n576 C=n577 Y=product[8]
XU539 AOI2BB1X1 $PINS A0N=n588 A1N=a[17] B0=n589 Y=n586
XU540 AND2X2 $PINS A=p12 B=a[10] Y=n671
XU541 OAI2BB1X1 $PINS A0N=p18 A1N=p15 B0=n700 Y=n681
XU542 XNOR3X2 $PINS A=n782 B=n784 C=n781 Y=n776
XU543 NAND2X1 $PINS A=n635 B=n634 Y=n619
XU544 OAI21XL $PINS A0=n599 A1=n934 B0=n919 Y=n925
XU545 INVXL $PINS A=n924 Y=n599
XU546 XOR2X2 $PINS A=n694 B=n540 Y=product[24]
XU547 XOR2X1 $PINS A=n591 B=n538 Y=product[32]
XU548 XNOR3X2 $PINS A=n879 B=a[8] C=n878 Y=n882
XU549 OAI21XL $PINS A0=n830 A1=n831 B0=n832 Y=n824
XU550 XOR3X2 $PINS A=n760 B=n757 C=n758 Y=n766
XU551 XOR3X2 $PINS A=a[2] B=p6 C=FE_OFN91_register_8__3 Y=n574
XU552 XNOR3X2 $PINS A=n776 B=n779 C=n778 Y=n771
XU553 OAI211X1 $PINS A0=n569 A1=n593 B0=n842 C0=n843 Y=n536
XU554 XOR3X2 $PINS A=n903 B=n900 C=n902 Y=product[13]
XU555 OAI221X4 $PINS A0=n656 A1=n655 B0=n663 B1=n639 C0=n657 Y=n603
XU556 INVX1 $PINS A=n662 Y=n663
XU558 OAI21XL $PINS A0=p6 A1=FE_OFN95_n B0=p23 Y=n913
XU559 XNOR2X1 $PINS A=FE_OFN86_register_8__16 B=n590 Y=n538
XU560 NOR2X1 $PINS A=n873 B=n523 Y=n848
XU562 OAI211X1 $PINS A0=n922 A1=n923 B0=n924 C0=n568 Y=n921
XU563 OAI21XL $PINS A0=FE_OFN17_N1034 A1=n944 B0=n945 Y=n923
XU564 INVX1 $PINS A=n872 Y=n567
XU566 AOI22X1 $PINS A0=n631 A1=n601 B0=n631 B1=n603 Y=n630
XU567 NOR2BX2 $PINS AN=n861 B=n684 Y=n830
XU568 AOI21X1 $PINS A0=FE_OFN8_register_8__15 A1=p17 B0=p8 Y=n748
XU569 OAI2BB1X1 $PINS A0N=n831 A1N=n830 B0=n833 Y=n832
XU570 OAI21X1 $PINS A0=_register_8_6 A1=n862 B0=n609 Y=n833
XU571 OAI221X1 $PINS A0=n640 A1=n613 B0=n640 B1=n614 C0=n629 Y=n632
XU572 AOI221X1 $PINS A0=n654 A1=n693 B0=n654 B1=n534 C0=n653 Y=n694
XU573 XOR2X1 $PINS A=n799 B=n796 Y=n537
XU576 NOR2XL $PINS A=a[11] B=FE_OFN85_N1424 Y=n858
XU578 OAI21XL $PINS A0=p4 A1=p14 B0=n836 Y=n816
XU581 XNOR2X1 $PINS A=n851 B=n546 Y=n873
XU582 XOR2X1 $PINS A=FE_RN_2 B=n818 Y=n797
XU587 OAI21XL $PINS A0=n813 A1=n814 B0=n815 Y=n794
XU588 XOR2X1 $PINS A=n537 B=n797 Y=n792
XU589 OAI2BB1X1 $PINS A0N=n703 A1N=n704 B0=n705 Y=n688
XU591 XNOR2X1 $PINS A=n669 B=n646 Y=n667
XU593 OR2X2 $PINS A=n811 B=n810 Y=n803
XU594 NAND2X1 $PINS A=n734 B=n733 Y=n715
XU595 NOR2X1 $PINS A=n755 B=n754 Y=n716
XU596 NAND2X1 $PINS A=n667 B=n668 Y=n641
XU597 OAI211X1 $PINS A0=n628 A1=n629 B0=n619 C0=n630 Y=n620
XU599 XOR2X1 $PINS A=n547 B=n548 Y=product[31]
XU600 AOI211X1 $PINS A0=n584 A1=n585 B0=p20 C0=n586 Y=product[34]
XU601 OAI222X1 $PINS A0=FE_OFN86_register_8__16 A1=n594 B0=n595 B1=p19 C0=n596
+ C1=n597 Y=n590
XU603 INVX1 $PINS A=n641 Y=n740
XU604 NAND2BX1 $PINS AN=n651 B=n652 Y=n670
XU606 INVX1 $PINS A=n628 Y=n761
XU607 INVX4 $PINS A=n664 Y=n564
XU608 XOR2X2 $PINS A=n541 B=n542 Y=product[26]
XU609 AOI22X1 $PINS A0=n658 A1=n659 B0=n660 B1=n661 Y=n657
XU610 OAI21XL $PINS A0=a[13] A1=p20 B0=n725 Y=n706
XU612 OAI21XL $PINS A0=a[19] A1=p14 B0=FE_OFN15_register_8__9 Y=n725
XU613 OAI21XL $PINS A0=n704 A1=n703 B0=n706 Y=n705
XU614 XNOR2X1 $PINS A=p20 B=FE_OFN23_register_8__16 Y=n585
XU615 OAI21XL $PINS A0=p18 A1=p15 B0=FE_OFN47_register_8__18 Y=n700
XU617 OAI21X2 $PINS A0=n716 A1=n564 B0=n714 Y=n731
XU618 XOR2XL $PINS A=p4 B=a[12] Y=n545
XU619 OAI2BB1X1 $PINS A0N=p4 A1N=n904 B0=n905 Y=n902
XU620 XNOR2X1 $PINS A=FE_OFN101_n B=p6 Y=n818
XU621 XOR2X1 $PINS A=a[12] B=n704 Y=n852
XU623 XNOR2X1 $PINS A=FE_OFN5792_register_8__9 B=p11 Y=n704
XU624 OAI21XL $PINS A0=FE_OFN23_register_8__16 A1=p18 B0=p23 Y=n726
XU625 XNOR2X1 $PINS A=FE_OFN101_n B=FE_OFN95_n Y=n907
XU626 OAI2BB1X1 $PINS A0N=n735 A1N=n736 B0=n737 Y=n733
XU627 OAI21XL $PINS A0=n736 A1=n735 B0=n738 Y=n737
XU628 AOI21X1 $PINS A0=n803 A1=n805 B0=n608 Y=n774
XU629 INVX1 $PINS A=n863 Y=n609
XU631 XOR2X1 $PINS A=n854 B=n852 Y=n546
XU632 OAI21XL $PINS A0=a[14] A1=a[4] B0=a[8] Y=n820
XU633 OAI21XL $PINS A0=n741 A1=n742 B0=n743 Y=n722
XU634 NOR2X2 $PINS A=FE_OFN101_n B=p11 Y=n684
XU635 XNOR2X1 $PINS A=p8 B=n907 Y=n906
XU636 OAI21XL $PINS A0=n671 A1=n672 B0=p12 Y=n647
XU637 OAI2BB1X1 $PINS A0N=n851 A1N=n852 B0=n853 Y=n845
XU638 NAND2X1 $PINS A=n523 B=n873 Y=n847
XU639 INVX1 $PINS A=n771 Y=n533
XU640 INVX1 $PINS A=n770 Y=n532
XU641 OAI21XL $PINS A0=n863 A1=n862 B0=a[4] Y=n941
XU642 AOI2BB1X1 $PINS A0N=n862 A1N=p22 B0=n863 Y=n576
XU643 INVX1 $PINS A=n640 Y=n749
XU644 OAI2BB1X1 $PINS A0N=n618 A1N=n761 B0=n619 Y=n616
XU645 NAND2X1 $PINS A=n810 B=n811 Y=n806
XU646 OAI21XL $PINS A0=n795 A1=n686 B0=n687 Y=n659
XU647 NOR2X1 $PINS A=n634 B=n635 Y=n628
XU649 XOR2X2 $PINS A=n731 B=n732 Y=product[22]
XU650 OAI21XL $PINS A0=a[4] A1=p6 B0=a[7] Y=n933
XU651 OAI21XL $PINS A0=n883 A1=n882 B0=n885 Y=n884
XU652 OAI21XL $PINS A0=n848 A1=n844 B0=n845 Y=n842
XU653 OAI2BB1XL $PINS A0N=FE_OFN17_N1034 A1N=n944 B0=FE_OFN91_register_8__3
+ Y=n945
XU654 OAI2BB1X1 $PINS A0N=p3 A1N=n914 B0=n915 Y=n896
XU655 XOR2X1 $PINS A=FE_OFN69_register_8__2 B=n682 Y=n840
XU656 OAI21XL $PINS A0=p3 A1=n914 B0=n916 Y=n915
XU657 XNOR2X1 $PINS A=p3 B=FE_OFN95_n Y=n881
XU659 XNOR2XL $PINS A=n580 B=n581 Y=n578
XU660 NAND3XL $PINS A=n614 B=n613 C=n641 Y=n642
XU661 NOR2XL $PINS A=a[19] B=FE_OFN47_register_8__18 Y=n588
XU662 OAI2BB1X1 $PINS A0N=n679 A1N=n527 B0=n692 Y=n685
XU664 XOR2X1 $PINS A=n670 B=p22 Y=n791
XU665 XOR2X1 $PINS A=FE_OFN19_N1034 B=FE_OFN5770_register_8__7 Y=n888
XU668 XNOR2X1 $PINS A=p2 B=a[2] Y=n940
XU669 XNOR2X2 $PINS A=a[1] B=a[3] Y=n583
XU670 NAND2X1 $PINS A=n601 B=n602 Y=n597
XU671 XOR2X1 $PINS A=FE_OFN61_n5323 B=n881 Y=n856
XU672 AOI2BB1X2 $PINS A0N=n532 A1N=n533 B0=n772 Y=n750
XU673 OAI2BB1XL $PINS A0N=n758 A1N=n757 B0=n760 Y=n759
XU674 OAI21XL $PINS A0=a[4] A1=n940 B0=n941 Y=n581
XU675 XOR2X1 $PINS A=a[14] B=n835 Y=n814
XU676 AND2X1 $PINS A=n920 B=n568 Y=n926
XU678 OAI2BB1X1 $PINS A0N=n878 A1N=n879 B0=n880 Y=n859
XU679 XNOR2X2 $PINS A=a[8] B=a[4] Y=n835
XU680 XOR2X2 $PINS A=n544 B=n888 Y=n903
XU681 OAI21X2 $PINS A0=n574 A1=n577 B0=n938 Y=n573
XU682 XNOR2X1 $PINS A=FE_OFN52_register_8__12 B=n585 Y=n672
XU683 XNOR2XL $PINS A=n578 B=n579 Y=product[7]
XU684 OAI21X1 $PINS A0=a[2] A1=n583 B0=FE_OFN17_N1034 Y=n579
XU686 OAI21X2 $PINS A0=p22 A1=a[5] B0=n933 Y=n914
XU687 OAI21XL $PINS A0=FE_OFN19_N1034 A1=a[5] B0=FE_OFN5792_register_8__9
+ Y=n876
XU688 NOR2X1 $PINS A=a[13] B=a[12] Y=n651
XU689 XOR2X1 $PINS A=p15 B=a[15] Y=n623
XU691 INVX1 $PINS A=n606 Y=n739
XU694 OR2X2 $PINS A=n661 B=n660 Y=n658
XU695 AND2X1 $PINS A=n594 B=n597 Y=n547
XU696 AND3X2 $PINS A=n662 B=n664 C=n665 Y=n601
XU697 AOI222X1 $PINS A0=n603 A1=n602 B0=n739 B1=n604 C0=a[17] C1=n605 Y=n594
XU698 NOR2X1 $PINS A=a[2] B=p2 Y=n862
XU700 OAI21X2 $PINS A0=n571 A1=n573 B0=n936 Y=n924
XU701 OAI2BB1X2 $PINS A0N=n571 A1N=n573 B0=n572 Y=n936
XU703 OAI21X2 $PINS A0=n579 A1=n580 B0=n939 Y=n577
XU704 OAI2BB1X2 $PINS A0N=n579 A1N=n580 B0=n581 Y=n939
XU705 OAI2BB1X2 $PINS A0N=n577 A1N=n574 B0=n576 Y=n938
XU706 NOR2X1 $PINS A=_register_8_6 B=a[4] Y=n929
XU707 OAI221XL $PINS A0=n612 A1=n613 B0=n612 B1=n614 C0=n606 Y=n611
XU708 INVX1 $PINS A=n611 Y=n565
XU709 OR2X2 $PINS A=n668 B=n667 Y=n607
XU710 OAI21XL $PINS A0=n766 A1=n765 B0=n768 Y=n767
XU711 XOR2X1 $PINS A=n807 B=n808 Y=product[18]
XU712 XOR2X1 $PINS A=n539 B=n675 Y=n661
XU713 XNOR2X1 $PINS A=n610 B=n627 Y=n625
XU714 OAI21XL $PINS A0=n600 A1=n840 B0=n841 Y=n839
XU715 OAI2BB1X2 $PINS A0N=FE_DBTN176_n869 A1N=n552 B0=n872 Y=n867
XU716 XOR2X1 $PINS A=n723 B=n707 Y=n718
XU717 OAI21XL $PINS A0=n797 A1=n796 B0=n799 Y=n798
XU718 XNOR2X1 $PINS A=FE_OFN61_n5323 B=n929 Y=n946
XU719 OAI2BB1X1 $PINS A0N=n587 A1N=n858 B0=n857 Y=n841
XU720 NOR2XL $PINS A=FE_OFN47_register_8__18 B=a[16] Y=n596
XU721 NOR2XL $PINS A=n618 B=n640 Y=n643
XU722 NOR2X1 $PINS A=n717 B=n718 Y=n666
XU723 NAND2XL $PINS A=n718 B=n717 Y=n656
XU724 OAI211X2 $PINS A0=n918 A1=n919 B0=n921 C0=n920 Y=n872
XU725 NOR2XL $PINS A=n895 B=n896 Y=n910
XU726 INVXL $PINS A=n659 Y=n550
XU727 OAI2BB1X1 $PINS A0N=n821 A1N=n822 B0=n823 Y=n811
XU728 OAI21XL $PINS A0=n822 A1=n821 B0=n824 Y=n823
XU729 OR2XL $PINS A=n605 B=a[17] Y=n604
XU730 OAI2BB1X1 $PINS A0N=n888 A1N=n889 B0=n890 Y=n871
XU731 OAI21XL $PINS A0=n889 A1=n888 B0=n891 Y=n890
XU732 AND2X2 $PINS A=n594 B=FE_OFN86_register_8__16 Y=n595
XU733 XOR2X1 $PINS A=n677 B=n674 Y=n539
XU734 XNOR2XL $PINS A=a[13] B=p15 Y=n637
XU735 NAND2BXL $PINS AN=n671 B=p12 Y=n680
XU736 XNOR2X1 $PINS A=p19 B=p18 Y=n598
XU737 XNOR2X1 $PINS A=FE_OFN47_register_8__18 B=n636 Y=n650
XU738 XNOR2X1 $PINS A=n670 B=p18 Y=n646
XU739 AOI211XL $PINS A0=n622 A1=n623 B0=n624 C0=n625 Y=n617
XU740 OAI21XL $PINS A0=a[4] A1=p11 B0=n899 Y=n885
XU741 OAI21XL $PINS A0=p12 A1=a[17] B0=n764 Y=n744
XU742 OAI21XL $PINS A0=n701 A1=FE_OFN8_register_8__15 B0=n702 Y=n689
XU743 XOR2X1 $PINS A=a[13] B=n746 Y=n728
XU744 INVX1 $PINS A=n806 Y=n608
XU745 INVX1 $PINS A=n656 Y=n653
XU746 INVX1 $PINS A=n809 Y=n575
XU747 OR2XL $PINS A=n690 B=n660 Y=n540
XU748 NOR2BXL $PINS AN=n715 B=n713 Y=n732
XU749 NAND2XL $PINS A=n803 B=n806 Y=n807
XU750 NAND2XL $PINS A=n774 B=n773 Y=n789
XU751 AND2X2 $PINS A=n607 B=n641 Y=n541
XU752 OR2XL $PINS A=n601 B=n603 Y=n542
XU753 AOI21XL $PINS A0=n749 A1=n740 B0=n618 Y=n629
XU754 AND3X1 $PINS A=n749 B=n607 C=n761 Y=n631
XU755 INVX1 $PINS A=n871 Y=n552
XU756 INVX1 $PINS A=n776 Y=n699
XU757 NOR2BX1 $PINS AN=n615 B=n617 Y=n621
XU758 XNOR2X4 $PINS A=n543 B=n585 Y=product[33]
XU759 XOR2X4 $PINS A=n584 B=n586 Y=n543
XU761 OAI21XL $PINS A0=n724 A1=n776 B0=n777 Y=n753
XU762 OAI21XL $PINS A0=n699 A1=n778 B0=n779 Y=n777
XU763 OAI2BB1X1 $PINS A0N=n796 A1N=n797 B0=n798 Y=n779
XU764 OAI2BB1X1 $PINS A0N=n636 A1N=n637 B0=n638 Y=n634
XU765 OAI21XL $PINS A0=n720 A1=n719 B0=n722 Y=n721
XU766 INVX1 $PINS A=n778 Y=n724
XU767 OAI2BB1X1 $PINS A0N=n765 A1N=n766 B0=n767 Y=n755
XU768 OAI2BB1X1 $PINS A0N=n791 A1N=n792 B0=n793 Y=n770
XU769 OAI21XL $PINS A0=n792 A1=n791 B0=n794 Y=n793
XU770 XNOR2X1 $PINS A=n872 B=n911 Y=product[12]
XU771 XOR2X1 $PINS A=n925 B=n926 Y=product[11]
XU772 NOR2X1 $PINS A=n922 B=n923 Y=n934
XU773 NAND2XL $PINS A=n928 B=n927 Y=n920
XU774 XNOR2X1 $PINS A=n570 B=n571 Y=product[9]
XU775 OAI21XL $PINS A0=n567 A1=n910 B0=n893 Y=n900
XU776 XNOR2X1 $PINS A=FE_OFN8_register_8__15 B=FE_OFN23_register_8__16 Y=n627
XU777 OAI2BB1X1 $PINS A0N=n622 A1N=n623 B0=p20 Y=n626
XU778 NOR2XL $PINS A=a[2] B=a[0] Y=n582
XU779 AOI2BB1X1 $PINS A0N=n623 A1N=n622 B0=p20 Y=n624
XU780 OAI21XL $PINS A0=FE_OFN86_register_8__16 A1=FE_OFN8_register_8__15
+ B0=n610 Y=n605
XU781 OAI21XL $PINS A0=a[13] A1=a[14] B0=p6 Y=n787
XU782 OAI21XL $PINS A0=p12 A1=a[12] B0=FE_OFN91_register_8__3 Y=n819
XU783 OAI21XL $PINS A0=p18 A1=n651 B0=n652 Y=n636
XU784 OAI2BB1X1 $PINS A0N=n686 A1N=n795 B0=n688 Y=n687
XU785 INVX1 $PINS A=n689 Y=n795
XU786 NAND2X1 $PINS A=a[14] B=a[13] Y=n622
XU787 OAI2BB1X1 $PINS A0N=n742 A1N=n741 B0=n744 Y=n743
XU788 XNOR2X1 $PINS A=a[6] B=n917 Y=n916
XU789 OAI21XL $PINS A0=FE_OFN69_register_8__2 A1=FE_OFN91_register_8__3 B0=p6
+ Y=n937
XU790 NAND2X1 $PINS A=a[12] B=a[13] Y=n652
XU791 OAI2BB1X1 $PINS A0N=n681 A1N=n682 B0=n683 Y=n674
XU792 OAI21XL $PINS A0=n682 A1=n681 B0=n684 Y=n683
XU793 XNOR2X1 $PINS A=FE_OFN95_n B=n623 Y=n765
XU794 XOR2X1 $PINS A=p12 B=n786 Y=n758
XU795 XNOR2X1 $PINS A=n680 B=n672 Y=n675
XU796 XNOR2X1 $PINS A=p12 B=n545 Y=n821
XU797 XOR2X1 $PINS A=a[14] B=n598 Y=n708
XU798 XOR2X1 $PINS A=a[12] B=n762 Y=n742
XU799 XNOR2X1 $PINS A=a[8] B=FE_OFN47_register_8__18 Y=n762
XU800 NAND2X1 $PINS A=p2 B=a[3] Y=n580
XU801 XNOR2X1 $PINS A=a[8] B=p6 Y=n917
XU802 OAI2BB1X1 $PINS A0N=n781 A1N=n782 B0=n783 Y=n768
XU803 OAI21XL $PINS A0=n782 A1=n781 B0=n784 Y=n783
XU804 XOR2X1 $PINS A=FE_OFN47_register_8__18 B=FE_OFN23_register_8__16 Y=n548
XU805 OAI2BB1X1 $PINS A0N=n674 A1N=n675 B0=n676 Y=n668
XU806 OAI21XL $PINS A0=n675 A1=n674 B0=n677 Y=n676
XU807 XNOR2X1 $PINS A=n831 B=n549 Y=n838
XU808 XOR2X1 $PINS A=p6 B=n637 Y=n778
XU809 XNOR2X1 $PINS A=n649 B=n647 Y=n669
XU810 XOR2X1 $PINS A=n637 B=n650 Y=n645
XU812 OAI21XL $PINS A0=n727 A1=n728 B0=n729 Y=n710
XU813 OAI21XL $PINS A0=a[15] A1=p6 B0=FE_OFN101_n Y=n801
XU814 OAI21XL $PINS A0=a[14] A1=a[15] B0=FE_OFN95_n Y=n763
XU815 NAND2XL $PINS A=a[15] B=a[14] Y=n610
XU816 OAI21XL $PINS A0=n589 A1=n588 B0=FE_OFN8_register_8__15 Y=n702
XU817 OAI21XL $PINS A0=FE_OFN89_register_8__15 A1=n588 B0=n790 Y=n677
XU818 INVX1 $PINS A=n589 Y=n790
XU819 OAI21XL $PINS A0=FE_OFN47_register_8__18 A1=FE_OFN5_register_8__12 B0=p23
+ Y=n747
XU820 OAI21XL $PINS A0=a[10] A1=p12 B0=FE_OFN69_register_8__2 Y=n837
XU821 XNOR2X1 $PINS A=a[10] B=a[11] Y=n682
XU822 OAI21XL $PINS A0=a[10] A1=p17 B0=n788 Y=n760
XU823 OAI21XL $PINS A0=FE_OFN23_register_8__16 A1=p11 B0=FE_OFN95_n Y=n788
XU824 OAI21XL $PINS A0=FE_OFN23_register_8__16 A1=FE_OFN5_register_8__12
+ B0=n673 Y=n649
XU825 OAI21XL $PINS A0=FE_OFN52_register_8__12 A1=a[16] B0=a[19] Y=n673
XU826 XOR2X1 $PINS A=a[19] B=n598 Y=n591
XU827 OAI21XL $PINS A0=a[10] A1=FE_OFN5792_register_8__9 B0=a[12] Y=n861
XU828 XNOR2X1 $PINS A=FE_OFN101_n B=a[19] Y=n746
XU829 XNOR2XL $PINS A=FE_OFN47_register_8__18 B=a[19] Y=n701
XU830 OAI21XL $PINS A0=a[10] A1=p22 B0=p23 Y=n899
XU831 XOR2X1 $PINS A=FE_OFN68_register_8__7 B=n627 Y=n735
XU832 OAI21XL $PINS A0=p18 A1=a[11] B0=FE_OFN68_register_8__7 Y=n764
XU833 OAI21XL $PINS A0=FE_OFN95_n A1=FE_OFN68_register_8__7
+ B0=FE_OFN15_register_8__9 Y=n909
XU834 XOR2X2 $PINS A=n685 B=n550 Y=n678
XU835 XOR2XL $PINS A=n582 B=n583 Y=product[6]
XU837 XNOR2XL $PINS A=n865 B=n846 Y=product[15]
XU838 OAI211X2 $PINS A0=n569 A1=n593 B0=n843 C0=n842 Y=n804
XU839 XNOR2XL $PINS A=n935 B=n924 Y=product[10]
XU840 XNOR2XL $PINS A=n572 B=n573 Y=n570
.ENDS

.SUBCKT CONV_DW01_add_40 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
*.CONNECT SUM[0] A[0]
*.CONNECT SUM[1] A[1]
*.CONNECT SUM[2] A[2]
XFE_OFC2103_n135 INVX1 $PINS A=n465 Y=FE_OFN6083_n135
XFE_OFC2102_n135 INVX8 $PINS A=n135 Y=n465
XFE_OFC1396_N1454 INVX1 $PINS A=n499 Y=FE_OFN5671_N1454
XFE_OFC1395_N1454 INVX1 $PINS A=B[34] Y=n499
XFE_OFC263_n512 INVXL $PINS A=n512 Y=n238
XFE_OFC222_n413 INVX1 $PINS A=n413 Y=n507
XFE_OFC215_n18 INVX1 $PINS A=n18 Y=n506
XFE_OFC187_N1415 INVX1 $PINS A=A[29] Y=n503
XFE_DBTC175_n172 INVX4 $PINS A=n172 Y=FE_DBTN175_n172
XU371 OAI2BB1X4 $PINS A0N=n239 A1N=n438 B0=n229 Y=n227
XU410 AOI21X1 $PINS A0=n427 A1=n485 B0=n483 Y=n139
XU412 NOR2X2 $PINS A=n123 B=n101 Y=n99
XU434 OAI21X2 $PINS A0=FE_DBTN175_n172 A1=n481 B0=n170 Y=n164
XU436 AOI21X2 $PINS A0=n413 A1=n482 B0=n478 Y=n159
XU482 XOR2X4 $PINS A=n85 B=n5 Y=SUM[29]
XU487 XNOR2X2 $PINS A=n144 B=n11 Y=SUM[23]
XU492 OAI21X4 $PINS A0=n124 A1=n101 B0=n102 Y=n100
XU493 XOR2X4 $PINS A=n107 B=n7 Y=SUM[27]
XU500 OAI21X4 $PINS A0=n185 A1=n173 B0=n174 Y=n172
XU501 XOR2X4 $PINS A=n129 B=n9 Y=SUM[25]
XU523 AND2X2 $PINS A=n431 B=n216 Y=n440
XU366 XOR2X4 $PINS A=n72 B=n4 Y=SUM[30]
XU382 AOI2BB1X1 $PINS A0N=n487 A1N=n495 B0=n496 Y=n65
XU406 OAI21XL $PINS A0=n475 A1=n489 B0=n93 Y=n87
XU421 AOI21X4 $PINS A0=n418 A1=n476 B0=n484 Y=n124
XU422 OR2X2 $PINS A=B[27] B=A[27] Y=n437
XU426 OR2X4 $PINS A=B[21] B=A[21] Y=n413
XU431 OR2X2 $PINS A=B[30] B=A[30] Y=n416
XU432 XOR2X2 $PINS A=n45 B=n1 Y=SUM[33]
XU459 OR2X4 $PINS A=B[25] B=A[25] Y=n418
XU462 OR2X2 $PINS A=A[10] B=B[10] Y=n421
XU468 OR2X2 $PINS A=B[23] B=A[23] Y=n427
XU474 OR2X4 $PINS A=B[33] B=A[33] Y=n434
XU477 NOR2X1 $PINS A=n79 B=n55 Y=n53
XU491 NAND2X2 $PINS A=n425 B=n414 Y=n79
XU494 OAI21X1 $PINS A0=FE_DBTN175_n172 A1=n158 B0=n159 Y=n153
XU564 NAND2X1 $PINS A=n424 B=n416 Y=n55
XU572 XOR2X2 $PINS A=n36 B=n499 Y=SUM[34]
XU331 AOI21X1 $PINS A0=n239 A1=n429 B0=n512 Y=n234
XU332 AOI21X1 $PINS A0=n421 A1=n512 B0=n468 Y=n229
XU334 CLKINVX3 $PINS A=n411 Y=n487
XU335 AOI21X1 $PINS A0=n498 A1=n436 B0=n497 Y=n256
XU336 INVX1 $PINS A=n260 Y=n497
XU337 NOR2X1 $PINS A=n221 B=n224 Y=n219
XU338 NAND2X1 $PINS A=n417 B=n426 Y=n191
XU339 NOR2X2 $PINS A=B[17] B=A[17] Y=n188
XU340 NOR2X1 $PINS A=A[5] B=B[5] Y=n254
XU341 NOR2X1 $PINS A=B[12] B=A[12] Y=n221
XU342 NAND2X1 $PINS A=A[7] B=B[7] Y=n247
XU343 NOR2X1 $PINS A=A[7] B=B[7] Y=n246
XU345 OAI21XL $PINS A0=n475 A1=n79 B0=n487 Y=n74
XU346 AOI21X1 $PINS A0=n496 A1=n424 B0=n488 Y=n56
XU347 OR2X2 $PINS A=B[31] B=A[31] Y=n424
XU348 INVX1 $PINS A=n416 Y=n495
XU349 XNOR2X1 $PINS A=n463 B=n16 Y=SUM[18]
XU350 OR2X2 $PINS A=B[20] B=A[20] Y=n432
XU351 NAND2X1 $PINS A=B[23] B=A[23] Y=n143
XU354 INVX1 $PINS A=n124 Y=n474
XU356 AOI21X2 $PINS A0=n50 A1=n423 B0=n493 Y=n45
XU357 AOI21X2 $PINS A0=n108 A1=n465 B0=n109 Y=n107
XU358 OAI2BB1X1 $PINS A0N=n425 A1N=n490 B0=n84 Y=n411
XU359 INVX1 $PINS A=n93 Y=n490
XU360 NOR2X1 $PINS A=n473 B=n79 Y=n73
XU361 INVX1 $PINS A=n99 Y=n473
XU362 AOI21X2 $PINS A0=n465 A1=n86 B0=n87 Y=n85
XU363 OAI2BB1X4 $PINS A0N=n449 A1N=n465 B0=n52 Y=n50
XU364 AOI21X1 $PINS A0=n480 A1=n420 B0=n479 Y=n174
XU365 INVX1 $PINS A=n178 Y=n479
XU367 AOI2BB1X2 $PINS A0N=n115 A1N=n444 B0=n486 Y=n102
XU368 INVX1 $PINS A=n437 Y=n444
XU369 AOI21X4 $PINS A0=n219 A1=n227 B0=n220 Y=n218
XU370 NAND2BX1 $PINS AN=n79 B=n416 Y=n64
XU372 NAND2X1 $PINS A=n434 B=n44 Y=n1
XU373 NOR2BX4 $PINS AN=n196 B=n453 Y=n192
XU374 XOR2X1 $PINS A=n212 B=n20 Y=SUM[14]
XU375 AND2X2 $PINS A=n99 B=n414 Y=n86
XU376 AOI21X2 $PINS A0=n493 A1=n434 B0=n494 Y=n40
XU377 INVX1 $PINS A=n106 Y=n486
XU379 NAND2XL $PINS A=n430 B=n183 Y=n16
XU380 NAND2X1 $PINS A=n422 B=n431 Y=n206
XU381 OAI21XL $PINS A0=n256 A1=n254 B0=n255 Y=n253
XU383 OAI2BB1X1 $PINS A0N=n227 A1N=n445 B0=n225 Y=n223
XU384 INVX1 $PINS A=n224 Y=n445
XU385 XOR2X2 $PINS A=n179 B=n15 Y=SUM[19]
XU386 AOI21X4 $PINS A0=n186 A1=n205 B0=n187 Y=n185
XU387 AOI21X1 $PINS A0=n253 A1=n433 B0=n466 Y=n248
XU388 INVX1 $PINS A=n252 Y=n466
XU389 INVX1 $PINS A=n71 Y=n496
XU390 OR2X2 $PINS A=n64 B=n473 Y=n451
XU391 XNOR2X1 $PINS A=n227 B=n23 Y=SUM[11]
XU392 OAI21XL $PINS A0=FE_DBTN175_n172 A1=n145 B0=n146 Y=n144
XU394 AND3X2 $PINS A=n434 B=n423 C=FE_OFN5671_N1454 Y=n33
XU395 OAI21XL $PINS A0=n491 A1=n124 B0=n115 Y=n109
XU396 NAND2X1 $PINS A=n437 B=n419 Y=n101
XU397 XNOR2X2 $PINS A=n153 B=n12 Y=SUM[22]
XU398 INVX1 $PINS A=n233 Y=n468
XU399 NAND2X1 $PINS A=A[10] B=B[10] Y=n233
XU400 NAND2X1 $PINS A=A[6] B=B[6] Y=n252
XU401 OR2X2 $PINS A=A[14] B=B[14] Y=n422
XU402 OR2X2 $PINS A=B[24] B=A[24] Y=n428
XU403 INVX2 $PINS A=n133 Y=n476
XU404 NAND2X1 $PINS A=B[24] B=A[24] Y=n133
XU405 XNOR2X1 $PINS A=n190 B=n17 Y=SUM[17]
XU407 XOR2X2 $PINS A=n462 B=n19 Y=SUM[15]
XU408 NAND2X1 $PINS A=B[28] B=A[28] Y=n93
XU409 AOI21X1 $PINS A0=n422 A1=n469 B0=n470 Y=n207
XU411 CLKINVX3 $PINS A=n205 Y=n462
XU413 NAND2X1 $PINS A=n430 B=n420 Y=n173
XU415 INVX1 $PINS A=n143 Y=n483
XU416 NAND2X1 $PINS A=B[13] B=A[13] Y=n216
XU417 INVX1 $PINS A=n218 Y=n461
XU418 NAND2X1 $PINS A=A[4] B=B[4] Y=n260
XU419 INVX1 $PINS A=n414 Y=n489
XU423 OR2X2 $PINS A=B[28] B=A[28] Y=n414
XU424 XNOR2X1 $PINS A=n28 B=n253 Y=SUM[6]
XU425 CLKINVX3 $PINS A=n185 Y=n463
XU427 OR2X2 $PINS A=B[18] B=A[18] Y=n430
XU428 OR2X2 $PINS A=B[19] B=A[19] Y=n420
XU429 NAND2X1 $PINS A=B[21] B=A[21] Y=n163
XU430 NAND2X2 $PINS A=B[20] B=A[20] Y=n170
XU433 XOR2X1 $PINS A=n234 B=n24 Y=SUM[10]
XU435 INVX1 $PINS A=n44 Y=n494
XU438 NAND2X1 $PINS A=B[33] B=A[33] Y=n44
XU439 INVX1 $PINS A=n49 Y=n493
XU440 AND2X2 $PINS A=n53 B=n99 Y=n449
XU442 NAND2X1 $PINS A=n426 B=n203 Y=n19
XU443 OR2X2 $PINS A=A[15] B=B[15] Y=n426
XU444 AOI21X1 $PINS A0=n463 A1=n430 B0=n480 Y=n179
XU445 AOI31X1 $PINS A0=n50 A1=n434 A2=n423 B0=n492 Y=n36
XU446 NOR2X2 $PINS A=n203 B=n452 Y=n453
XU447 INVX1 $PINS A=n417 Y=n452
XU448 INVX1 $PINS A=n128 Y=n484
XU449 OR2X4 $PINS A=B[22] B=A[22] Y=n415
XU450 OAI21X2 $PINS A0=n192 A1=n188 B0=n189 Y=n187
XU451 NAND2X1 $PINS A=B[22] B=A[22] Y=n152
XU452 OAI21X1 $PINS A0=n462 A1=n471 B0=n203 Y=n197
XU453 OAI21X1 $PINS A0=n138 A1=n159 B0=n139 Y=n137
XU454 NAND2X1 $PINS A=n415 B=n427 Y=n138
XU455 CLKINVX3 $PINS A=n100 Y=n475
XU456 NOR2X1 $PINS A=n188 B=n191 Y=n186
XU457 AOI21X4 $PINS A0=n465 A1=n428 B0=n476 Y=n129
XU458 OR2X2 $PINS A=n218 B=n206 Y=n446
XU460 NAND2X2 $PINS A=n446 B=n207 Y=n205
XU461 INVX1 $PINS A=n152 Y=n485
XU464 NAND2X1 $PINS A=B[18] B=A[18] Y=n183
XU465 NAND2X1 $PINS A=A[5] B=B[5] Y=n255
XU466 INVX1 $PINS A=n216 Y=n469
XU467 NAND2X1 $PINS A=A[3] B=B[3] Y=n263
XU469 NOR2X1 $PINS A=n138 B=n158 Y=n455
XU470 NAND2X1 $PINS A=B[19] B=A[19] Y=n178
XU471 INVX1 $PINS A=n183 Y=n480
XU472 INVX1 $PINS A=n163 Y=n478
XU473 INVX1 $PINS A=n170 Y=n482
XU475 OR2X2 $PINS A=B[26] B=A[26] Y=n419
XU476 NAND2X1 $PINS A=B[26] B=A[26] Y=n115
XU478 XNOR2X2 $PINS A=n223 B=n22 Y=SUM[12]
XU480 NAND2X1 $PINS A=n429 B=n238 Y=n458
XU481 INVX1 $PINS A=n419 Y=n491
XU483 NAND2X1 $PINS A=B[27] B=A[27] Y=n106
XU484 INVX1 $PINS A=n60 Y=n488
XU485 NAND2X1 $PINS A=n432 B=n170 Y=n14
XU489 INVX1 $PINS A=n432 Y=n481
XU490 NAND2X1 $PINS A=A[15] B=B[15] Y=n203
XU496 AOI21X2 $PINS A0=n73 A1=n465 B0=n74 Y=n72
XU497 OAI21XL $PINS A0=n487 A1=n55 B0=n56 Y=n54
XU498 OAI2BB2XL $PINS A0N=n50 A1N=n33 B0=n40 B1=n499 Y=SUM[35]
XU499 XOR2X2 $PINS A=FE_DBTN175_n172 B=n14 Y=SUM[20]
XU502 INVX1 $PINS A=n159 Y=n477
XU503 NAND2BX1 $PINS AN=n158 B=n415 Y=n145
XU504 OR2X2 $PINS A=n475 B=n64 Y=n460
XU505 AOI2BB1X2 $PINS A0N=n451 A1N=FE_OFN6083_n135 B0=n63 Y=n61
XU506 OR2X2 $PINS A=A[4] B=B[4] Y=n436
XU507 OAI2BB1X2 $PINS A0N=n245 A1N=n435 B0=n244 Y=n239
XU508 NOR2X1 $PINS A=n491 B=n123 Y=n108
XU509 XNOR2X2 $PINS A=n164 B=n454 Y=SUM[21]
XU511 NAND2XL $PINS A=n436 B=n260 Y=n30
XU512 AND2X2 $PINS A=n421 B=n429 Y=n438
XU513 OR2X2 $PINS A=A[9] B=B[9] Y=n429
XU514 NAND2X1 $PINS A=B[30] B=A[30] Y=n71
XU515 AOI21X1 $PINS A0=n461 A1=n431 B0=n469 Y=n212
XU516 NAND2X2 $PINS A=n418 B=n428 Y=n123
XU517 INVX1 $PINS A=n40 Y=n492
XU518 NAND2X1 $PINS A=B[32] B=A[32] Y=n49
XU519 INVX1 $PINS A=n123 Y=n472
XU520 OAI21X1 $PINS A0=n248 A1=n246 B0=n247 Y=n245
XU521 AOI21X2 $PINS A0=n465 A1=n99 B0=n100 Y=n94
XU524 OR2X2 $PINS A=A[16] B=B[16] Y=n417
XU525 AOI21X4 $PINS A0=n465 A1=n472 B0=n474 Y=n116
XU526 AOI21X1 $PINS A0=n53 A1=n100 B0=n54 Y=n52
XU527 NAND2BX1 $PINS AN=n188 B=n189 Y=n17
XU528 NAND2X1 $PINS A=B[17] B=A[17] Y=n189
XU529 INVX1 $PINS A=n211 Y=n470
XU530 AND2X2 $PINS A=n423 B=n49 Y=n457
XU531 NAND2X1 $PINS A=B[29] B=A[29] Y=n84
XU532 OR2X2 $PINS A=A[6] B=B[6] Y=n433
XU533 XOR2X2 $PINS A=n50 B=n457 Y=SUM[32]
XU534 NAND2XL $PINS A=n435 B=n244 Y=n26
XU535 NAND2XL $PINS A=n413 B=n163 Y=n454
XU536 NAND2XL $PINS A=n422 B=n211 Y=n20
XU537 AOI21X4 $PINS A0=n455 A1=n172 B0=n137 Y=n135
XU538 NAND2XL $PINS A=B[12] B=A[12] Y=n222
XU539 XOR2XL $PINS A=n29 B=n256 Y=SUM[5]
XU540 NAND2BXL $PINS AN=n254 B=n255 Y=n29
XU541 XNOR2XL $PINS A=n30 B=n498 Y=SUM[4]
XU542 XOR2X4 $PINS A=n61 B=n456 Y=SUM[31]
XU543 NAND2XL $PINS A=n424 B=n60 Y=n456
XU544 NOR2XL $PINS A=A[3] B=B[3] Y=n262
XU545 OR2X2 $PINS A=B[32] B=A[32] Y=n423
XU546 NAND2XL $PINS A=n420 B=n178 Y=n15
XU547 NAND2XL $PINS A=n437 B=n106 Y=n7
XU548 NAND2XL $PINS A=n425 B=n84 Y=n5
XU549 NAND2XL $PINS A=n427 B=n143 Y=n11
XU550 NAND2X1 $PINS A=n417 B=n196 Y=n18
XU551 INVXL $PINS A=n426 Y=n471
XU552 NAND2BX1 $PINS AN=n221 B=n222 Y=n22
XU554 NAND2XL $PINS A=n421 B=n233 Y=n24
XU555 NAND2BX1 $PINS AN=n224 B=n225 Y=n23
XU556 XNOR2X1 $PINS A=n245 B=n26 Y=SUM[8]
XU557 XOR2X1 $PINS A=n248 B=n27 Y=SUM[7]
XU558 NAND2BX1 $PINS AN=n246 B=n247 Y=n27
XU559 XNOR2X1 $PINS A=n239 B=n458 Y=SUM[9]
XU560 OR2X2 $PINS A=B[13] B=A[13] Y=n431
XU561 NAND2X1 $PINS A=A[8] B=B[8] Y=n244
XU562 NAND2X1 $PINS A=A[14] B=B[14] Y=n211
XU563 OR2X2 $PINS A=A[8] B=B[8] Y=n435
XU565 NOR2X1 $PINS A=A[11] B=B[11] Y=n224
XU566 NAND2X1 $PINS A=A[11] B=B[11] Y=n225
XU567 NAND2X1 $PINS A=B[16] B=A[16] Y=n196
XU568 NAND2X1 $PINS A=n433 B=n252 Y=n28
XU569 INVX1 $PINS A=n263 Y=n498
XU570 NOR2BX1 $PINS AN=n263 B=n262 Y=SUM[3]
XU571 NAND2X1 $PINS A=B[31] B=A[31] Y=n60
XU573 XNOR2X4 $PINS A=n116 B=n459 Y=SUM[26]
XU574 AND2X1 $PINS A=n419 B=n115 Y=n459
XU575 NAND2XL $PINS A=n415 B=n152 Y=n12
XU576 NAND2XL $PINS A=n418 B=n128 Y=n9
XU577 NAND2X1 $PINS A=n460 B=n65 Y=n63
XU578 NAND2X1 $PINS A=B[25] B=A[25] Y=n128
XU579 NAND2X1 $PINS A=n416 B=n71 Y=n4
XU333 XNOR2X4 $PINS A=n135 B=n500 Y=SUM[24]
XU344 AND2X2 $PINS A=n428 B=n133 Y=n500
XU352 XNOR2X2 $PINS A=n94 B=n501 Y=SUM[28]
XU353 AND2X2 $PINS A=n414 B=n93 Y=n501
XU355 AND2X2 $PINS A=n477 B=n415 Y=n502
XU378 NOR2X1 $PINS A=n502 B=n485 Y=n146
XU414 NAND2BX1 $PINS AN=B[29] B=n503 Y=n425
XU479 OAI2BB1X1 $PINS A0N=n205 A1N=n504 B0=n192 Y=n190
XU486 INVX1 $PINS A=n191 Y=n504
XU488 OR2X2 $PINS A=n221 B=n225 Y=n505
XU510 NAND2X1 $PINS A=n505 B=n222 Y=n220
XU553 XOR2X2 $PINS A=n197 B=n506 Y=SUM[16]
XU581 NAND2BX2 $PINS AN=n507 B=n432 Y=n158
XU585 XNOR2X1 $PINS A=n218 B=n440 Y=SUM[13]
XU588 NOR2BX1 $PINS AN=A[9] B=n513 Y=n512
XU590 INVX1 $PINS A=B[9] Y=n513
.ENDS

.SUBCKT CONV_DW_mult_uns_47 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[14] b[13]
+ b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0]
+ product[34] product[33] product[32] product[31] product[30] product[29]
+ product[28] product[27] product[26] product[25] product[24] product[23]
+ product[22] product[21] product[20] product[19] product[18] product[17]
+ product[16] product[15] product[14] product[13] product[12] product[11]
+ product[10] product[9] product[8] product[7] product[6] product[5] product[4]
+ product[3] product[2] product[1] product[0] p1 p2 p3 p4
+ FE_OFN502_register_6__18
*.CONNECT p1 p2
XFE_OFC1997_register_6__10 BUFX3 $PINS A=a[10] Y=FE_OFN6025_register_6__10
XFE_OFC1969_register_6__16 BUFX3 $PINS A=a[16] Y=FE_OFN5996_register_6__16
XFE_OFC1961_register_6__14 BUFX3 $PINS A=a[14] Y=FE_OFN5988_register_6__14
XFE_OFC1869_n144 CLKINVX3 $PINS A=n559 Y=FE_OFN5922_n144
XFE_OFC1868_n144 INVXL $PINS A=n559 Y=FE_OFN5921_n144
XFE_OFC1867_n144 INVX1 $PINS A=n144 Y=n559
XFE_OFC1796_N872 BUFX3 $PINS A=a[1] Y=FE_OFN5886_N872
XFE_OFC1749_n546 INVX1 $PINS A=n558 Y=FE_OFN5860_n546
XFE_OFC1748_n546 INVX1 $PINS A=n546 Y=n558
XFE_OFC1701_register_6__8 CLKINVX3 $PINS A=a[8] Y=FE_OFN5831_register_6__8
XFE_OFC592_n230 INVX1 $PINS A=n230 Y=n575
XFE_OFC216_n199 CLKINVX3 $PINS A=n199 Y=FE_DBTN174_n199
XU444 AND2X2 $PINS A=n161 B=n560 Y=n150
XU537 OAI21XL $PINS A0=n221 A1=n209 B0=n210 Y=n208
XU578 CMPR42X1 $PINS A=n385 B=n381 C=n382 D=n386 ICI=n379 S=n376 ICO=n374
+ CO=n375
XU581 CMPR42X1 $PINS A=FE_OFN6025_register_6__10 B=n393 C=n389 D=n394 ICI=n387
+ S=n384 ICO=n382 CO=n383
XU477 AOI21X1 $PINS A0=n222 A1=n230 B0=n223 Y=n221
XU488 OR2X2 $PINS A=n405 B=n400 Y=n528
XU511 NOR2X1 $PINS A=n368 B=n375 Y=n191
XU534 AOI21X1 $PINS A0=n145 A1=n162 B0=n146 Y=n144
XU399 ADDHXL $PINS A=a[17] B=a[11] S=n333 CO=n332
XU400 OAI21XL $PINS A0=n571 A1=n205 B0=n206 Y=n204
XU401 NAND2X1 $PINS A=n400 B=n405 Y=n214
XU402 OR2X2 $PINS A=n199 B=n196 Y=n540
XU403 NAND2X1 $PINS A=n540 B=n197 Y=n541
XU404 NOR2X1 $PINS A=n376 B=n383 Y=n196
XU405 NAND2X1 $PINS A=n376 B=n383 Y=n197
XU406 INVX1 $PINS A=n541 Y=n193
XU407 CMPR32X1 $PINS A=FE_OFN5886_N872 B=a[7] C=a[12] S=n408 CO=n407
XU408 ADDFX2 $PINS A=p3 B=a[4] CI=a[7] S=n427 CO=n426
XU409 XNOR2X1 $PINS A=n238 B=n30 Y=product[8]
XU410 OAI21XL $PINS A0=n574 A1=n239 B0=n240 Y=n238
XU411 XNOR2X1 $PINS A=n33 B=n250 Y=product[5]
XU412 OAI21XL $PINS A0=n254 A1=n251 B0=n252 Y=n250
XU413 NOR2X1 $PINS A=n344 B=n351 Y=n168
XU414 OR2X1 $PINS A=n202 B=n206 Y=n525
XU415 NAND2X1 $PINS A=n528 B=n529 Y=n209
XU416 NAND2X1 $PINS A=n392 B=n399 Y=n206
XU417 CMPR32X1 $PINS A=a[11] B=a[5] C=FE_OFN5996_register_6__16 S=n357 CO=n356
XU418 NOR2X1 $PINS A=n384 B=n391 Y=n202
XU419 NAND2X1 $PINS A=n406 B=n412 Y=n219
XU420 OR2X2 $PINS A=n406 B=n412 Y=n529
XU421 NAND2XL $PINS A=a[3] B=a[0] Y=n254
XU422 OAI21XL $PINS A0=FE_OFN5922_n144 A1=n69 B0=n70 Y=n68
XU423 AND3X2 $PINS A=n545 B=n525 C=n203 Y=n199
XU424 OAI2BB2X1 $PINS A0N=n285 A1N=FE_OFN502_register_6__18 B0=n42 B1=n40 Y=n39
XU425 NAND2BXL $PINS AN=n236 B=n237 Y=n30
XU426 OAI21XL $PINS A0=FE_OFN5922_n144 A1=n45 B0=n46 Y=n44
XU427 INVXL $PINS A=n242 Y=n574
XU428 OAI21XL $PINS A0=n147 A1=n155 B0=n148 Y=n146
XU429 OAI2BB2X1 $PINS A0N=n429 A1N=n543 B0=n550 B1=n245 Y=n242
XU431 NAND2X1 $PINS A=n533 B=n103 Y=n101
XU432 XNOR2X1 $PINS A=n542 B=n17 Y=product[21]
XU433 OAI2BB2X1 $PINS A0N=n286 A1N=n287 B0=n53 B1=n65 Y=n52
XU434 OAI21XL $PINS A0=n555 A1=n182 B0=n183 Y=n179
XU435 INVX1 $PINS A=n190 Y=n555
XU436 OAI2BB1X1 $PINS A0N=n557 A1N=n170 B0=n169 Y=n542
XU437 NOR2X1 $PINS A=n101 B=n138 Y=n537
XU438 AOI21X1 $PINS A0=n572 A1=n528 B0=n573 Y=n210
XU439 INVX1 $PINS A=n214 Y=n573
XU440 OAI21XL $PINS A0=n175 A1=n183 B0=n176 Y=n174
XU441 OAI21XL $PINS A0=FE_OFN5921_n144 A1=n138 B0=n139 Y=n133
XU443 CMPR42X1 $PINS A=a[7] B=FE_OFN6025_register_6__10 C=n341 D=n348 ICI=n345
+ S=n339 ICO=n337 CO=n338
XU445 AOI21X1 $PINS A0=FE_DBTN174_n199 A1=n189 B0=n190 Y=n184
XU446 NOR2X1 $PINS A=n352 B=n359 Y=n175
XU448 NOR2X1 $PINS A=n336 B=n343 Y=n163
XU449 NOR2X1 $PINS A=n392 B=n399 Y=n205
XU450 CMPR42X1 $PINS A=a[11] B=FE_OFN5988_register_6__14 C=n398 D=n402 ICI=n395
+ S=n392 ICO=n390 CO=n391
XU451 NAND2BXL $PINS AN=n205 B=n206 Y=n24
XU452 ADDFXL $PINS A=p3 B=a[11] CI=FE_OFN5996_register_6__16 S=n381 CO=n380
XU453 CMPR32X1 $PINS A=a[17] B=a[11] C=a[13] S=n312 CO=n311
XU455 AOI21X1 $PINS A0=n173 A1=n190 B0=n174 Y=n172
XU456 ADDFX2 $PINS A=a[5] B=a[3] CI=n425 S=n423 CO=n422
XU457 OAI21XL $PINS A0=n101 A1=n139 B0=n102 Y=n4
XU458 OAI21XL $PINS A0=FE_OFN5922_n144 A1=n110 B0=n111 Y=n109
XU459 CMPR42X1 $PINS A=n361 B=n364 C=n362 D=n355 ICI=n358 S=n352 ICO=n350
+ CO=n351
XU461 NAND2X1 $PINS A=n352 B=n359 Y=n176
XU462 CMPR42X1 $PINS A=a[11] B=a[9] C=n325 D=n330 ICI=n326 S=n322 ICO=n320
+ CO=n321
XU464 NOR2X1 $PINS A=n309 B=n305 Y=n116
XU465 XOR2X1 $PINS A=n140 B=n548 Y=product[24]
XU466 OAI21XL $PINS A0=n163 A1=n169 B0=n164 Y=n162
XU467 NOR2X1 $PINS A=n163 B=n168 Y=n161
XU468 AND2X2 $PINS A=a[0] B=p3 Y=n543
XU469 AND2X2 $PINS A=a[0] B=FE_OFN5831_register_6__8 Y=n544
XU471 NAND2X1 $PINS A=n336 B=n343 Y=n164
XU473 CMPR42X1 $PINS A=a[5] B=n373 C=n374 D=n378 ICI=n371 S=n368 ICO=n366
+ CO=n367
XU474 NAND2XL $PINS A=n368 B=n375 Y=n192
XU475 CMPR42X1 $PINS A=FE_OFN5886_N872 B=FE_OFN5831_register_6__8 C=a[5] D=n407
+ ICI=n403 S=n400 ICO=n398 CO=n399
XU476 NOR2X1 $PINS A=n413 B=n417 Y=n224
XU478 CMPR42X1 $PINS A=FE_OFN5831_register_6__8 B=a[6] C=a[3] D=n415 ICI=n416
+ S=n413 ICO=n411 CO=n412
XU479 XOR2X1 $PINS A=a[0] B=p3 Y=n431
XU480 OR2X2 $PINS A=n431 B=a[5] Y=n531
XU481 NAND2X1 $PINS A=n431 B=a[5] Y=n249
XU482 XOR2X1 $PINS A=a[0] B=FE_OFN5831_register_6__8 Y=n425
XU483 ADDHX1 $PINS A=a[0] B=a[9] S=n410 CO=n409
XU484 INVX1 $PINS A=n537 Y=n562
XU485 NAND2X1 $PINS A=n112 B=n561 Y=n110
XU486 NAND2X1 $PINS A=n537 B=n47 Y=n45
XU487 INVXL $PINS A=n196 Y=n554
XU489 XNOR3X2 $PINS A=n42 B=n285 C=FE_OFN502_register_6__18 Y=product[32]
XU490 NOR2X1 $PINS A=n321 B=n315 Y=n138
XU491 XOR2X1 $PINS A=n94 B=n10 Y=product[28]
XU492 AOI21XL $PINS A0=n95 A1=n170 B0=n96 Y=n94
XU493 XNOR3X2 $PINS A=n66 B=n291 C=n288 Y=product[30]
XU494 NOR2XL $PINS A=FE_OFN5860_n546 B=n69 Y=n67
XU495 NAND2X1 $PINS A=n344 B=n351 Y=n169
XU496 NOR2X1 $PINS A=n322 B=n327 Y=n147
XU497 ADDFX2 $PINS A=FE_OFN5886_N872 B=a[7] CI=a[15] S=n389 CO=n388
XU498 ADDHXL $PINS A=a[0] B=a[11] S=n415 CO=n414
XU499 CMPR42X1 $PINS A=n372 B=n365 C=n370 D=n363 ICI=n366 S=n360 ICO=n358
+ CO=n359
XU500 ADDFX2 $PINS A=a[12] B=a[13] CI=FE_OFN6025_register_6__10 S=n317 CO=n316
XU501 NOR2X1 $PINS A=n205 B=n202 Y=n547
XU502 INVX1 $PINS A=n139 Y=n563
XU503 INVX1 $PINS A=n130 Y=n565
XU504 INVX1 $PINS A=n219 Y=n572
XU505 AOI21X1 $PINS A0=n242 A1=n234 B0=n235 Y=n233
XU506 OAI21XL $PINS A0=n236 A1=n240 B0=n237 Y=n235
XU507 NOR2X1 $PINS A=n421 B=n422 Y=n231
XU508 NOR2X1 $PINS A=n418 B=n420 Y=n227
XU509 INVX1 $PINS A=n4 Y=n564
XU510 NOR2X1 $PINS A=n175 B=n182 Y=n173
XU512 XOR2X1 $PINS A=n107 B=n11 Y=product[27]
XU513 AOI21X1 $PINS A0=n108 A1=n170 B0=n109 Y=n107
XU514 NAND2BX1 $PINS AN=n251 B=n252 Y=n34
XU515 XNOR3X2 $PINS A=n55 B=n286 C=n287 Y=product[31]
XU516 NOR2X1 $PINS A=FE_OFN5860_n546 B=n58 Y=n56
XU517 XOR2X1 $PINS A=n81 B=n9 Y=product[29]
XU518 XOR2X1 $PINS A=n177 B=n19 Y=product[19]
XU520 XOR2X1 $PINS A=n131 B=n13 Y=product[25]
XU521 AOI21X1 $PINS A0=n132 A1=n170 B0=n133 Y=n131
XU522 XOR2X1 $PINS A=n118 B=n12 Y=product[26]
XU523 AOI21X1 $PINS A0=n119 A1=n170 B0=n120 Y=n118
XU524 AOI21X1 $PINS A0=n170 A1=n558 B0=n559 Y=n140
XU525 XOR2X1 $PINS A=n156 B=n16 Y=product[22]
XU526 AOI21X1 $PINS A0=n170 A1=n161 B0=n162 Y=n156
XU527 XOR2X1 $PINS A=n149 B=n15 Y=product[23]
XU528 NOR2XL $PINS A=a[4] B=a[1] Y=n251
XU529 ADDFX2 $PINS A=FE_OFN5886_N872 B=a[6] CI=a[3] S=n429 CO=n428
XU530 ADDHXL $PINS A=a[19] B=FE_OFN5996_register_6__16 S=n302 CO=n301
XU531 AOI21X1 $PINS A0=n250 A1=n531 B0=n577 Y=n245
XU532 NOR2X1 $PINS A=n360 B=n367 Y=n182
XU533 CMPR42X1 $PINS A=n302 B=n323 C=n317 D=n324 ICI=n320 S=n315 ICO=n313
+ CO=n314
XU535 NAND2X1 $PINS A=n547 B=n208 Y=n545
XU538 NAND2BX1 $PINS AN=n227 B=n228 Y=n28
XU539 XOR2XL $PINS A=n29 B=n233 Y=product[9]
XU540 NAND2BXL $PINS AN=n231 B=n232 Y=n29
XU541 XOR2X1 $PINS A=n24 B=n571 Y=product[14]
XU542 NOR2X1 $PINS A=n429 B=n543 Y=n550
XU543 OAI21XL $PINS A0=n224 A1=n228 B0=n225 Y=n223
XU544 NOR2X1 $PINS A=n224 B=n227 Y=n222
XU545 INVX1 $PINS A=n138 Y=n561
XU546 NAND2BXL $PINS AN=n202 B=n203 Y=n23
XU547 AOI21XL $PINS A0=n82 A1=n170 B0=n83 Y=n81
XU548 NAND2X1 $PINS A=n413 B=n417 Y=n225
XU549 AOI21XL $PINS A0=n67 A1=n170 B0=n68 Y=n66
XU550 AOI21XL $PINS A0=n4 A1=n566 B0=n567 Y=n70
XU551 NAND2X1 $PINS A=n537 B=n60 Y=n58
XU552 OAI21XL $PINS A0=n105 A1=n117 B0=n106 Y=n104
XU553 AOI21X1 $PINS A0=n103 A1=n565 B0=n104 Y=n102
XU554 NAND2X1 $PINS A=n161 B=n145 Y=n546
XU555 NAND2X1 $PINS A=n537 B=n566 Y=n69
XU556 AOI21X1 $PINS A0=n43 A1=n170 B0=n44 Y=n42
XU557 OAI21XL $PINS A0=n130 A1=n116 B0=n117 Y=n113
XU558 NAND2BXL $PINS AN=n163 B=n164 Y=n17
XU559 NAND2X1 $PINS A=n530 B=n51 Y=n49
XU560 NAND2X1 $PINS A=n423 B=n426 Y=n237
XU561 CMPR42X1 $PINS A=a[13] B=FE_OFN5996_register_6__16 C=n346 D=n339 ICI=n342
+ S=n336 ICO=n334 CO=n335
XU562 INVX1 $PINS A=n221 Y=n570
XU563 INVX1 $PINS A=n208 Y=n571
XU564 NOR2XL $PINS A=FE_OFN5860_n546 B=n84 Y=n82
XU565 NOR2XL $PINS A=FE_OFN5860_n546 B=n45 Y=n43
XU566 INVXL $PINS A=n74 Y=n567
XU567 OAI21XL $PINS A0=n233 A1=n231 B0=n232 Y=n230
XU568 NOR2X1 $PINS A=n154 B=n147 Y=n145
XU569 NAND2XL $PINS A=n533 B=n130 Y=n13
XU570 NAND2BXL $PINS AN=n182 B=n183 Y=n20
XU571 NAND2XL $PINS A=n534 B=n93 Y=n10
XU572 NAND2BXL $PINS AN=n105 B=n106 Y=n11
XU573 AOI21X1 $PINS A0=n112 A1=n563 B0=n113 Y=n111
XU574 NAND2XL $PINS A=n561 B=n139 Y=n548
XU575 NAND2XL $PINS A=n530 B=n80 Y=n9
XU576 INVXL $PINS A=n168 Y=n557
XU577 INVXL $PINS A=n154 Y=n560
XU579 AOI21XL $PINS A0=n563 A1=n533 B0=n565 Y=n122
XU580 AOI21XL $PINS A0=n4 A1=n47 B0=n48 Y=n46
XU582 AOI21XL $PINS A0=n51 A1=n569 B0=n52 Y=n50
XU583 INVXL $PINS A=n182 Y=n556
XU584 NAND2XL $PINS A=n561 B=n533 Y=n121
XU585 XNOR2X1 $PINS A=n170 B=n549 Y=product[20]
XU586 NAND2XL $PINS A=n557 B=n169 Y=n549
XU587 NAND2XL $PINS A=n560 B=n155 Y=n16
XU588 NOR2XL $PINS A=n73 B=n64 Y=n60
XU589 NOR2X1 $PINS A=n423 B=n426 Y=n236
XU590 NAND2X1 $PINS A=n418 B=n420 Y=n228
XU591 NAND2XL $PINS A=n309 B=n305 Y=n117
XU592 NAND2XL $PINS A=n322 B=n327 Y=n148
XU593 NAND2XL $PINS A=n360 B=n367 Y=n183
XU594 ADDFX2 $PINS A=a[17] B=a[9] CI=a[12] S=n373 CO=n372
XU595 NOR2X1 $PINS A=FE_OFN5860_n546 B=n562 Y=n95
XU596 NOR2X1 $PINS A=FE_OFN5860_n546 B=n110 Y=n108
XU598 NAND2BXL $PINS AN=n175 B=n176 Y=n19
XU599 OAI21XL $PINS A0=FE_OFN5922_n144 A1=n562 B0=n564 Y=n96
XU600 NOR2X1 $PINS A=FE_OFN5860_n546 B=n121 Y=n119
XU601 INVX1 $PINS A=n73 Y=n566
XU602 NOR2X1 $PINS A=n239 B=n236 Y=n234
XU603 XNOR2X1 $PINS A=FE_DBTN174_n199 B=n22 Y=product[16]
XU604 NAND2XL $PINS A=n554 B=n197 Y=n22
XU605 XNOR2X1 $PINS A=n204 B=n23 Y=product[15]
XU606 XOR2X1 $PINS A=n193 B=n21 Y=product[17]
XU607 NAND2BXL $PINS AN=n191 B=n192 Y=n21
XU608 XOR2X1 $PINS A=n184 B=n20 Y=product[18]
XU609 XOR2X1 $PINS A=n575 B=n28 Y=product[10]
XU610 XOR2X1 $PINS A=n215 B=n25 Y=product[13]
XU611 NAND2XL $PINS A=n528 B=n214 Y=n25
XU612 AOI21X1 $PINS A0=n570 A1=n529 B0=n572 Y=n215
XU613 AOI21X1 $PINS A0=n568 A1=n530 B0=n569 Y=n74
XU614 NOR2BX1 $PINS AN=n533 B=n116 Y=n112
XU615 NOR2X1 $PINS A=n64 B=n53 Y=n51
XU616 NOR2X1 $PINS A=n116 B=n105 Y=n103
XU617 NOR2BX1 $PINS AN=n534 B=n49 Y=n47
XU618 NAND2XL $PINS A=n537 B=n534 Y=n84
XU619 OAI21XL $PINS A0=FE_OFN5922_n144 A1=n84 B0=n85 Y=n83
XU620 AOI21XL $PINS A0=n4 A1=n534 B0=n568 Y=n85
XU621 OAI21XL $PINS A0=FE_OFN5922_n144 A1=n58 B0=n59 Y=n57
XU622 AOI21XL $PINS A0=n4 A1=n60 B0=n61 Y=n59
XU623 OAI21XL $PINS A0=n74 A1=n64 B0=n65 Y=n61
XU624 OAI21XL $PINS A0=FE_OFN5922_n144 A1=n121 B0=n122 Y=n120
XU625 NAND2X1 $PINS A=n534 B=n530 Y=n73
XU626 OAI21XL $PINS A0=n49 A1=n93 B0=n50 Y=n48
XU627 NOR2XL $PINS A=n546 B=n138 Y=n132
XU628 INVX1 $PINS A=n93 Y=n568
XU629 INVX1 $PINS A=n80 Y=n569
XU630 XNOR2X1 $PINS A=n570 B=n26 Y=product[12]
XU631 NAND2XL $PINS A=n529 B=n219 Y=n26
XU632 XNOR2X1 $PINS A=n226 B=n27 Y=product[11]
XU633 NAND2BX1 $PINS AN=n224 B=n225 Y=n27
XU634 OAI21XL $PINS A0=n575 A1=n227 B0=n228 Y=n226
XU635 NAND2BX1 $PINS AN=n147 B=n148 Y=n15
XU636 AOI21X1 $PINS A0=n170 A1=n150 B0=n151 Y=n149
XU637 NAND2BX1 $PINS AN=n116 B=n117 Y=n12
XU638 OAI2BB1X1 $PINS A0N=n162 A1N=n560 B0=n155 Y=n151
XU639 NOR2X1 $PINS A=n428 B=n427 Y=n239
XU640 INVX1 $PINS A=n249 Y=n577
XU641 NAND2X1 $PINS A=n428 B=n427 Y=n240
XU642 NAND2X1 $PINS A=n384 B=n391 Y=n203
XU643 XOR3X2 $PINS A=n242 B=n428 C=n427 Y=product[7]
XU644 NOR2X1 $PINS A=n291 B=n288 Y=n64
XU645 NOR2X1 $PINS A=n300 B=n304 Y=n105
XU646 OR2X2 $PINS A=n314 B=n310 Y=n533
XU647 OR2X2 $PINS A=n299 B=n297 Y=n534
XU648 NAND2X1 $PINS A=n321 B=n315 Y=n139
XU649 OR2X2 $PINS A=n296 B=n292 Y=n530
XU650 NOR2X1 $PINS A=n286 B=n287 Y=n53
XU651 NAND2X1 $PINS A=n328 B=n335 Y=n155
XU652 NOR2X1 $PINS A=n285 B=FE_OFN502_register_6__18 Y=n40
XU653 NAND2X1 $PINS A=n314 B=n310 Y=n130
XU654 NAND2X1 $PINS A=n299 B=n297 Y=n93
XU655 NOR2X1 $PINS A=n328 B=n335 Y=n154
XU656 NAND2X1 $PINS A=n291 B=n288 Y=n65
XU657 NAND2X1 $PINS A=n421 B=n422 Y=n232
XU658 NAND2X1 $PINS A=n300 B=n304 Y=n106
XU659 NAND2X1 $PINS A=n296 B=n292 Y=n80
XU660 XNOR3X2 $PINS A=n429 B=n543 C=n245 Y=product[6]
XU661 AOI21XL $PINS A0=n56 A1=n170 B0=n57 Y=n55
XU662 NAND2X1 $PINS A=n531 B=n249 Y=n33
XU663 NOR2BX1 $PINS AN=n39 B=p4 Y=product[34]
XU664 XOR2X1 $PINS A=n34 B=n254 Y=product[4]
XU665 XNOR2X1 $PINS A=n39 B=p4 Y=product[33]
XU666 ADDFX2 $PINS A=FE_OFN502_register_6__18 B=a[4] CI=a[13] S=n365 CO=n364
XU667 CMPR42X1 $PINS A=p3 B=a[7] C=a[5] D=FE_OFN6025_register_6__10 ICI=n419
+ S=n418 ICO=n416 CO=n417
XU668 CMPR42X1 $PINS A=a[7] B=a[6] C=a[15] D=FE_OFN6025_register_6__10 ICI=n369
+ S=n363 ICO=n361 CO=n362
XU669 CMPR42X1 $PINS A=FE_OFN5988_register_6__14 B=a[6] C=a[3] D=n377 ICI=n380
+ S=n371 ICO=n369 CO=n370
XU670 CMPR42X1 $PINS A=p3 B=a[13] C=FE_OFN6025_register_6__10 D=n409 ICI=n404
+ S=n403 ICO=n401 CO=n402
XU671 CMPR42X1 $PINS A=p3 B=a[6] C=a[3] D=n410 ICI=n401 S=n395 ICO=n393 CO=n394
XU672 ADDHXL $PINS A=a[17] B=FE_OFN502_register_6__18 S=n294 CO=n293
XU673 ADDHXL $PINS A=a[17] B=a[9] S=n349 CO=n348
XU674 ADDFX2 $PINS A=a[17] B=a[19] CI=n289 S=n286 CO=n285
XU675 ADDFX2 $PINS A=a[15] B=n294 CI=n295 S=n292 CO=n291
XU676 ADDHXL $PINS A=FE_OFN502_register_6__18 B=FE_OFN5988_register_6__14
+ S=n307 CO=n306
XU677 ADDFX2 $PINS A=FE_OFN5996_register_6__16 B=n293 CI=n290 S=n288 CO=n287
XU678 ADDHXL $PINS A=FE_OFN502_register_6__18 B=a[9] S=n341 CO=n340
XU679 ADDHXL $PINS A=FE_OFN502_register_6__18 B=a[19] S=n290 CO=n289
XU680 CMPR42X1 $PINS A=a[13] B=a[15] C=n306 D=n302 ICI=n303 S=n300 ICO=n298
+ CO=n299
XU681 CMPR42X1 $PINS A=a[19] B=FE_OFN5831_register_6__8 C=n338 D=n331 ICI=n334
+ S=n328 ICO=n326 CO=n327
XU682 CMPR42X1 $PINS A=a[6] B=a[12] C=n354 D=n347 ICI=n350 S=n344 ICO=n342
+ CO=n343
XU683 CMPR42X1 $PINS A=a[12] B=a[15] C=n307 D=n311 ICI=n308 S=n305 ICO=n303
+ CO=n304
XU684 CMPR42X1 $PINS A=FE_OFN5988_register_6__14 B=n301 C=n312 D=n316 ICI=n313
+ S=n310 ICO=n308 CO=n309
XU685 CMPR42X1 $PINS A=a[17] B=FE_OFN5988_register_6__14
+ C=FE_OFN5996_register_6__16 D=n301 ICI=n298 S=n297 ICO=n295 CO=n296
XU686 CMPR42X1 $PINS A=FE_OFN5988_register_6__14 B=a[7] C=a[19]
+ D=FE_OFN5831_register_6__8 ICI=n357 S=n355 ICO=n353 CO=n354
XU687 CMPR42X1 $PINS A=FE_OFN502_register_6__18 B=a[12] C=a[15] D=n332 ICI=n329
+ S=n325 ICO=n323 CO=n324
XU688 CMPR42X1 $PINS A=FE_OFN5831_register_6__8 B=a[15] C=n349 D=n353 ICI=n356
+ S=n347 ICO=n345 CO=n346
XU689 XOR2X1 $PINS A=a[3] B=a[0] Y=product[3]
XU690 CMPR42X1 $PINS A=FE_OFN5988_register_6__14 B=FE_OFN6025_register_6__10
+ C=n333 D=n340 ICI=n337 S=n331 ICO=n329 CO=n330
XU692 NAND2XL $PINS A=a[4] B=a[1] Y=n252
XU693 CMPR42X1 $PINS A=a[4] B=n410 C=n414 D=n411 ICI=n408 S=n406 ICO=n404
+ CO=n405
XU694 CMPR42X1 $PINS A=FE_OFN5886_N872 B=a[4] C=a[9] D=a[6] ICI=n544 S=n421
+ ICO=n419 CO=n420
XU695 CMPR42X1 $PINS A=a[4] B=a[12] C=a[3] D=n409 ICI=n390 S=n387 ICO=n385
+ CO=n386
XU696 CMPR42X1 $PINS A=a[4] B=FE_OFN5831_register_6__8 C=a[5] D=a[13] ICI=n388
+ S=n379 ICO=n377 CO=n378
XU430 OR2X2 $PINS A=n191 B=n196 Y=n578
XU447 INVX1 $PINS A=n578 Y=n189
XU463 OAI2BB1X4 $PINS A0N=n580 A1N=FE_DBTN174_n199 B0=n172 Y=n170
XU536 AND2X2 $PINS A=n173 B=n189 Y=n580
XU697 AND3X2 $PINS A=n556 B=FE_DBTN174_n199 C=n189 Y=n581
XU698 NOR2X1 $PINS A=n581 B=n179 Y=n177
XU699 OAI2BB1X1 $PINS A0N=n582 A1N=n583 B0=n192 Y=n190
XU700 INVX1 $PINS A=n191 Y=n582
XU701 INVX1 $PINS A=n197 Y=n583
.ENDS

.SUBCKT CONV_DW_mult_uns_48 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[14] b[13]
+ b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0]
+ product[34] product[33] product[32] product[31] product[30] product[29]
+ product[28] product[27] product[26] product[25] product[24] product[23]
+ product[22] product[21] product[20] product[19] product[18] product[17]
+ product[16] product[15] product[14] product[13] product[12] product[11]
+ product[10] product[9] product[8] product[7] product[6] product[5] product[4]
+ product[3] product[2] product[1] product[0] n4937 p1 p2 p3 p4 p5 p6 p7 p8 p9
+ p10 p11 p12 p13 p14 p15 p16 p17 p18 p19 p20 FE_OFN13_register_4__16
+ FE_OFN25_register_4__7 FE_OFN26_register_4__13 FE_OFN27_register_4__6
+ FE_OFN35_register_4__9 FE_OFN34_register_4__9 FE_OFN41_register_4__14
+ FE_OFN285_register_4__10 FE_OFN594_n4937 _register_4_14 _register_4_8
+ _register_4_11 _register_4_10 p21 FE_OFN62_register_4__18
+ FE_OFN78_register_4__11 FE_OFN80_register_4__10 FE_OFN81_register_4__8
+ FE_OFN92_register_4__7 FE_OFN98_n6728 FE_OFN5865_register_4__11
+ FE_OFN5748_register_4__13 FE_OFN5740_register_4__19 FE_OFN5745_register_4__14
+ FE_OFN5910_register_4__16
*.CONNECT FE_RN_6 a[0]
*.CONNECT p2 p3
XFE_OFC2081_n6728 INVX1 $PINS A=a[17] Y=FE_OFN6072_n6728
XFE_OFC1847_register_4__16 INVX1 $PINS A=FE_OFN13_register_4__16 Y=FE_RN_5
XFE_OFC1773_register_4__10 INVX1 $PINS A=_register_4_10
+ Y=FE_OFN5872_register_4__10
XFE_DBTC173_n130 INVX1 $PINS A=n130 Y=FE_DBTN173_n130
XFE_DBTC172_n151 INVX1 $PINS A=n151 Y=FE_DBTN172_n151
XFE_DBTC171_n187 INVX1 $PINS A=n187 Y=FE_DBTN171_n187
XU424 AOI31X1 $PINS A0=n509 A1=FE_DBTN173_n130 A2=n158 B0=n91 Y=n1
XU442 AND2X2 $PINS A=n114 B=n527 Y=n101
XU474 AOI21X1 $PINS A0=n215 A1=n234 B0=n216 Y=n214
XU405 AND2X2 $PINS A=n132 B=n151 Y=n500
XU406 NOR2X1 $PINS A=n500 B=n133 Y=n131
XU407 OAI221XL $PINS A0=n516 A1=n119 B0=n131 B1=n123 C0=n124 Y=n118
XU408 NAND2X1 $PINS A=n365 B=n368 Y=n194
XU409 NOR2X1 $PINS A=n363 B=n364 Y=n190
XU410 NOR2X1 $PINS A=n123 B=n116 Y=n114
XU411 ADDHXL $PINS A=_register_4_8 B=FE_RN_6 S=n357 CO=n356
XU413 NOR2X1 $PINS A=n350 B=n354 Y=n170
XU416 NAND2BXL $PINS AN=n163 B=n164 Y=n19
XU421 NOR2X1 $PINS A=n503 B=n545 Y=n221
XU422 INVX1 $PINS A=n225 Y=n545
XU425 AOI22X1 $PINS A0=n205 A1=n494 B0=n369 B1=n370 Y=n198
XU426 NOR2X1 $PINS A=n184 B=n179 Y=n177
XU427 NOR2X1 $PINS A=n163 B=n170 Y=n161
XU428 NAND2BX1 $PINS AN=n170 B=n171 Y=n20
XU429 OAI31X1 $PINS A0=n1 A1=n87 A2=n84 B0=n528 Y=n79
XU430 NAND2BXL $PINS AN=n155 B=n156 Y=n18
XU431 OAI31X1 $PINS A0=n1 A1=n73 A2=n499 B0=n530 Y=n50
XU432 XOR3X2 $PINS A=n68 B=n298 C=n297 Y=product[29]
XU433 AOI21X1 $PINS A0=FE_DBTN171_n187 A1=n517 B0=n518 Y=n181
XU435 OAI31X1 $PINS A0=n1 A1=n73 A2=n66 B0=n529 Y=n61
XU436 OAI21XL $PINS A0=n519 A1=n170 B0=n171 Y=n167
XU437 INVX1 $PINS A=n178 Y=n519
XU438 OAI21XL $PINS A0=n116 A1=n124 B0=n117 Y=n115
XU439 NAND2XL $PINS A=n523 B=n150 Y=n137
XU440 OAI2BB2X1 $PINS A0N=n290 A1N=a[18] B0=n38 B1=n36 Y=n35
XU441 AND2X2 $PINS A=n161 B=n177 Y=n504
XU443 NOR2X1 $PINS A=n155 B=n152 Y=n150
XU444 OAI21XL $PINS A0=n532 A1=n231 B0=n232 Y=n226
XU445 INVX1 $PINS A=n234 Y=n532
XU446 XNOR2X1 $PINS A=n61 B=n6 Y=product[30]
XU447 AOI31X1 $PINS A0=FE_DBTN171_n187 A1=n501 A2=n177 B0=n167 Y=n165
XU448 INVX1 $PINS A=n170 Y=n501
XU449 XOR3X2 $PINS A=n196 B=n365 C=n368 Y=product[12]
XU450 OAI221XL $PINS A0=n59 A1=n67 B0=n499 B1=n74 C0=n60 Y=n54
XU451 AND3X2 $PINS A=n495 B=a[2] C=a[6] Y=n503
XU452 OAI221XL $PINS A0=n516 A1=n137 B0=FE_DBTN172_n151 B1=n141 C0=n142 Y=n136
XU454 AOI21X1 $PINS A0=n533 A1=n538 B0=n539 Y=n208
XU455 OAI21XL $PINS A0=n532 A1=n220 B0=n221 Y=n219
XU456 AOI21X1 $PINS A0=FE_DBTN171_n187 A1=n177 B0=n178 Y=n172
XU457 XOR2X1 $PINS A=n165 B=n19 Y=product[17]
XU458 OAI21XL $PINS A0=n206 A1=n212 B0=n207 Y=n205
XU459 OR2X2 $PINS A=FE_OFN25_register_4__7 B=n377 Y=n495
XU460 OAI2BB2X1 $PINS A0N=n375 A1N=n498 B0=n221 B1=n217 Y=n216
XU461 NAND2X1 $PINS A=n504 B=FE_DBTN171_n187 Y=n506
XU462 NAND2X1 $PINS A=n506 B=n160 Y=n158
XU463 INVX2 $PINS A=n158 Y=n516
XU464 XNOR2X1 $PINS A=FE_OFN5740_register_4__19 B=FE_OFN5910_register_4__16
+ Y=n317
XU465 NOR2X1 $PINS A=n371 B=n372 Y=n206
XU466 OAI21XL $PINS A0=n163 A1=n171 B0=n164 Y=n162
XU467 NOR2X1 $PINS A=n345 B=n349 Y=n163
XU468 NOR2X1 $PINS A=n105 B=n96 Y=n94
XU470 NOR2X1 $PINS A=n319 B=n315 Y=n116
XU473 OAI21XL $PINS A0=n247 A1=n235 B0=n236 Y=n234
XU475 INVX1 $PINS A=n240 Y=n535
XU476 ADDFX2 $PINS A=p7 B=a[2] CI=p11 S=n373 CO=n372
XU477 NOR2X1 $PINS A=n206 B=n211 Y=n204
XU479 XOR2X1 $PINS A=n172 B=n20 Y=product[16]
XU480 XOR2X1 $PINS A=n181 B=n21 Y=product[15]
XU482 INVX1 $PINS A=n509 Y=n92
XU483 XNOR2X1 $PINS A=n107 B=n12 Y=product[24]
XU484 OAI221XL $PINS A0=n131 A1=n525 B0=n516 B1=n108 C0=n526 Y=n107
XU485 XNOR2X1 $PINS A=n154 B=n17 Y=product[19]
XU486 XNOR2X1 $PINS A=n118 B=n13 Y=product[23]
XU487 NAND2BX1 $PINS AN=n116 B=n117 Y=n13
XU488 NAND2X1 $PINS A=FE_DBTN173_n130 B=n524 Y=n119
XU489 XNOR2X1 $PINS A=n98 B=n11 Y=product[25]
XU492 INVX1 $PINS A=n196 Y=n534
XU493 CMPR42X1 $PINS A=FE_OFN5865_register_4__11 B=FE_OFN5745_register_4__14
+ C=n346 D=n342 ICI=n343 S=n340 ICO=n338 CO=n339
XU494 OAI21XL $PINS A0=n179 A1=n185 B0=n180 Y=n178
XU495 NOR2X1 $PINS A=n359 B=n355 Y=n179
XU496 AOI21XL $PINS A0=n533 A1=n204 B0=n205 Y=n203
XU497 AOI21X1 $PINS A0=n188 A1=n196 B0=n189 Y=n187
XU498 NOR2X1 $PINS A=n141 B=n134 Y=n132
XU499 NAND2X1 $PINS A=n150 B=n132 Y=n130
XU501 NOR2X1 $PINS A=n340 B=n344 Y=n155
XU502 AOI21XL $PINS A0=n115 A1=n94 B0=n95 Y=n93
XU503 ADDFX2 $PINS A=a[5] B=a[17] CI=a[2] S=n347 CO=n346
XU505 OAI21XL $PINS A0=n197 A1=n214 B0=n198 Y=n196
XU506 NAND2X1 $PINS A=n253 B=n248 Y=n247
XU507 NOR2X1 $PINS A=a[1] B=FE_RN_6 Y=n253
XU508 NOR2X1 $PINS A=n373 B=n374 Y=n211
XU510 ADDFX2 $PINS A=FE_OFN6072_n6728 B=FE_OFN13_register_4__16
+ CI=FE_OFN5745_register_4__14 S=n297 CO=n296
XU511 OAI21XL $PINS A0=n1 A1=n44 B0=n45 Y=n43
XU512 CMPR42X1 $PINS A=FE_OFN5748_register_4__13 B=FE_OFN5872_register_4__10
+ C=n347 D=n351 ICI=n348 S=n345 ICO=n343 CO=n344
XU513 OAI21XL $PINS A0=n190 A1=n194 B0=n191 Y=n189
XU514 NOR2X1 $PINS A=n190 B=n193 Y=n188
XU515 NAND2X1 $PINS A=n360 B=n362 Y=n185
XU516 INVX1 $PINS A=n115 Y=n526
XU517 NAND2X1 $PINS A=FE_RN_6 B=a[4] Y=n245
XU518 NAND2BX1 $PINS AN=FE_RN_6 B=p6 Y=n491
XU519 INVX1 $PINS A=n247 Y=n537
XU520 INVX1 $PINS A=n253 Y=n536
XU521 ADDFX2 $PINS A=p6 B=p10 CI=a[1] S=n375 CO=n374
XU522 INVX1 $PINS A=n214 Y=n533
XU523 XOR2X1 $PINS A=n516 B=n18 Y=product[18]
XU524 NAND2X1 $PINS A=n340 B=n344 Y=n156
XU526 XNOR2X1 $PINS A=n86 B=n9 Y=product[27]
XU527 XOR3X2 $PINS A=n79 B=n300 C=n299 Y=product[28]
XU528 XNOR2X1 $PINS A=n125 B=n14 Y=product[22]
XU529 XNOR2X1 $PINS A=n15 B=n136 Y=product[21]
XU530 XOR2X1 $PINS A=n1 B=n10 Y=product[26]
XU532 CMPR42X1 $PINS A=p14 B=a[1] C=n356 D=n353 ICI=n352 S=n350 ICO=n348
+ CO=n349
XU533 INVXL $PINS A=n211 Y=n538
XU534 NOR2X1 $PINS A=n220 B=n217 Y=n215
XU535 NOR2X1 $PINS A=n375 B=n498 Y=n217
XU536 OAI21XL $PINS A0=n152 A1=n156 B0=n153 Y=n151
XU537 NAND2X1 $PINS A=n495 B=n547 Y=n220
XU538 OAI21XL $PINS A0=n534 A1=n193 B0=n194 Y=n192
XU539 ADDFX2 $PINS A=FE_OFN13_register_4__16 B=a[4] CI=a[9] S=n352 CO=n351
XU540 ADDFX2 $PINS A=p6 B=FE_OFN78_register_4__11 CI=a[7] S=n369 CO=n368
XU541 AND2X2 $PINS A=n114 B=n94 Y=n509
XU542 NAND2BXL $PINS AN=n190 B=n191 Y=n23
XU543 XOR2X1 $PINS A=n143 B=n511 Y=product[20]
XU544 NOR2XL $PINS A=n87 B=n84 Y=n82
XU545 NOR2X1 $PINS A=a[2] B=a[6] Y=n231
XU546 INVXL $PINS A=n212 Y=n539
XU547 AOI21X1 $PINS A0=n161 A1=n178 B0=n162 Y=n160
XU548 OAI21XL $PINS A0=n99 A1=n516 B0=n100 Y=n98
XU549 OAI21XL $PINS A0=n84 A1=n88 B0=n85 Y=n83
XU550 NOR2X1 $PINS A=n335 B=n339 Y=n152
XU551 NAND2X1 $PINS A=n363 B=n364 Y=n191
XU552 NAND2X1 $PINS A=n325 B=n329 Y=n135
XU553 INVXL $PINS A=n54 Y=n530
XU554 XOR2X1 $PINS A=n208 B=n26 Y=product[10]
XU555 NAND2XL $PINS A=n547 B=n232 Y=n30
XU556 NAND2XL $PINS A=n495 B=n225 Y=n29
XU557 INVXL $PINS A=n185 Y=n518
XU558 XNOR2X1 $PINS A=FE_DBTN171_n187 B=n510 Y=product[14]
XU559 NAND2XL $PINS A=n517 B=n185 Y=n510
XU560 NAND2XL $PINS A=FE_DBTN173_n130 B=n101 Y=n99
XU561 NAND2BXL $PINS AN=n96 B=n97 Y=n11
XU562 AND2X1 $PINS A=n523 B=n142 Y=n511
XU563 OAI21XL $PINS A0=n516 A1=n155 B0=n156 Y=n154
XU564 OAI21XL $PINS A0=n516 A1=n130 B0=n131 Y=n125
XU565 NAND2XL $PINS A=n524 B=n124 Y=n14
XU566 INVXL $PINS A=n114 Y=n525
XU567 NAND2XL $PINS A=n527 B=n106 Y=n12
XU568 INVXL $PINS A=n141 Y=n523
XU569 OAI21XL $PINS A0=n1 A1=n87 B0=n88 Y=n86
XU570 INVXL $PINS A=n123 Y=n524
XU571 NAND2XL $PINS A=a[1] B=a[5] Y=n240
XU572 NAND2XL $PINS A=n493 B=n240 Y=n31
XU573 AOI21XL $PINS A0=n537 A1=n491 B0=n549 Y=n241
XU574 NAND2XL $PINS A=n493 B=n491 Y=n235
XU575 NAND2XL $PINS A=a[2] B=a[6] Y=n232
XU576 NAND2XL $PINS A=n359 B=n355 Y=n180
XU577 XOR2X1 $PINS A=n50 B=n512 Y=product[31]
XU578 XOR2X1 $PINS A=n294 B=n293 Y=n512
XU579 NAND2XL $PINS A=n335 B=n339 Y=n153
XU580 AOI22XL $PINS A0=n43 A1=n497 B0=n292 B1=n291 Y=n38
XU581 NAND2XL $PINS A=n319 B=n315 Y=n117
XU582 INVXL $PINS A=n83 Y=n528
XU583 NAND2XL $PINS A=n298 B=n297 Y=n67
XU584 NAND2XL $PINS A=n296 B=n295 Y=n60
XU585 NOR2XL $PINS A=n536 B=a[2] Y=n250
XU587 ADDFX2 $PINS A=p3 B=a[12] CI=n367 S=n365 CO=n364
XU589 XNOR2X1 $PINS A=p7 B=FE_RN_5 Y=n332
XU590 XNOR2X1 $PINS A=a[15] B=p19 Y=n322
XU591 NOR2XL $PINS A=n290 B=a[18] Y=n36
XU592 CMPR32X1 $PINS A=FE_OFN5740_register_4__19 B=FE_OFN5910_register_4__16
+ C=a[18] S=n293 CO=n292
XU594 OAI21XL $PINS A0=n131 A1=n92 B0=n93 Y=n91
XU595 INVX1 $PINS A=n131 Y=n522
XU596 NAND2XL $PINS A=FE_DBTN173_n130 B=n114 Y=n108
XU597 NOR2X1 $PINS A=n73 B=n499 Y=n53
XU598 NAND2BX1 $PINS AN=n59 B=n60 Y=n6
XU599 NAND2X1 $PINS A=n204 B=n494 Y=n197
XU600 NAND2BX1 $PINS AN=n87 B=n88 Y=n10
XU601 NAND2BX1 $PINS AN=n134 B=n135 Y=n15
XU602 XOR2X1 $PINS A=n203 B=n25 Y=product[11]
XU603 NAND2X1 $PINS A=n494 B=n202 Y=n25
XU604 NAND2BX1 $PINS AN=n152 B=n153 Y=n17
XU605 XNOR2X1 $PINS A=n533 B=n27 Y=product[9]
XU606 NAND2X1 $PINS A=n538 B=n212 Y=n27
XU607 OAI21XL $PINS A0=n1 A1=n73 B0=n74 Y=n68
XU608 NAND2BX1 $PINS AN=n84 B=n85 Y=n9
XU609 NAND2BX1 $PINS AN=n179 B=n180 Y=n21
XU610 NAND2BX1 $PINS AN=n206 B=n207 Y=n26
XU611 AOI21XL $PINS A0=n101 A1=n522 B0=n102 Y=n100
XU612 OAI21XL $PINS A0=n526 A1=n105 B0=n106 Y=n102
XU613 OAI21XL $PINS A0=n96 A1=n106 B0=n97 Y=n95
XU614 XNOR2X1 $PINS A=n192 B=n23 Y=product[13]
XU615 XOR2X1 $PINS A=n532 B=n30 Y=product[6]
XU616 OAI2BB1X1 $PINS A0N=n158 A1N=n150 B0=FE_DBTN172_n151 Y=n143
XU617 INVX1 $PINS A=n184 Y=n517
XU618 INVX1 $PINS A=n231 Y=n547
XU619 INVX1 $PINS A=n245 Y=n549
XU620 XNOR2X1 $PINS A=n226 B=n29 Y=product[7]
XU621 INVX1 $PINS A=n105 Y=n527
XU622 NAND2X1 $PINS A=n82 B=n492 Y=n73
XU623 OR2X2 $PINS A=n66 B=n59 Y=n499
XU624 INVX1 $PINS A=n489 Y=n529
XU625 OAI21XL $PINS A0=n74 A1=n66 B0=n67 Y=n489
XU626 OR2X2 $PINS A=n292 B=n291 Y=n497
XU627 NOR2X1 $PINS A=n314 B=n312 Y=n105
XU628 NOR2X1 $PINS A=n309 B=n311 Y=n96
XU629 NOR2X1 $PINS A=n365 B=n368 Y=n193
XU630 NAND2X1 $PINS A=n53 B=n496 Y=n44
XU631 AOI22X1 $PINS A0=n54 A1=n496 B0=n294 B1=n293 Y=n45
XU632 OR2X2 $PINS A=n294 B=n293 Y=n496
XU633 NAND2X1 $PINS A=n350 B=n354 Y=n171
XU634 NAND2X1 $PINS A=n314 B=n312 Y=n106
XU635 NAND2X1 $PINS A=n334 B=n330 Y=n142
XU636 NAND2X1 $PINS A=n320 B=n324 Y=n124
XU637 NAND2X1 $PINS A=n373 B=n374 Y=n212
XU638 NOR2X1 $PINS A=n360 B=n362 Y=n184
XU639 NOR2X1 $PINS A=n320 B=n324 Y=n123
XU640 NOR2X1 $PINS A=n334 B=n330 Y=n141
XU641 OR2X2 $PINS A=a[1] B=a[5] Y=n493
XU642 OR2X2 $PINS A=n369 B=n370 Y=n494
XU643 XNOR2X1 $PINS A=n537 B=n32 Y=product[4]
XU644 NAND2XL $PINS A=n491 B=n245 Y=n32
XU645 NAND2X1 $PINS A=FE_OFN25_register_4__7 B=n377 Y=n225
XU646 NAND2X1 $PINS A=n345 B=n349 Y=n164
XU647 NAND2X1 $PINS A=n309 B=n311 Y=n97
XU648 XOR2X1 $PINS A=n241 B=n31 Y=product[5]
XU649 NAND2X1 $PINS A=n371 B=n372 Y=n207
XU650 XNOR3X2 $PINS A=n38 B=n290 C=a[18] Y=product[33]
XU651 NAND2X1 $PINS A=n369 B=n370 Y=n202
XU652 AOI21X1 $PINS A0=n493 A1=n549 B0=n535 Y=n236
XU653 XOR3X2 $PINS A=n43 B=n292 C=n291 Y=product[32]
XU654 XOR3X2 $PINS A=n219 B=n375 C=n498 Y=product[8]
XU655 XOR2X1 $PINS A=n536 B=a[2] Y=product[2]
XU656 XOR2X1 $PINS A=a[1] B=FE_RN_6 Y=product[1]
XU657 AOI22X1 $PINS A0=n83 A1=n492 B0=n300 B1=n299 Y=n74
XU658 NOR2X1 $PINS A=n298 B=n297 Y=n66
XU659 NOR2X1 $PINS A=n306 B=n308 Y=n87
XU660 NOR2X1 $PINS A=n305 B=n301 Y=n84
XU661 NOR2X1 $PINS A=n296 B=n295 Y=n59
XU662 NAND2X1 $PINS A=n306 B=n308 Y=n88
XU663 NAND2X1 $PINS A=n305 B=n301 Y=n85
XU664 OR2X2 $PINS A=n300 B=n299 Y=n492
XU669 CMPR42X1 $PINS A=p19 B=FE_OFN5748_register_4__13 C=a[10] D=a[12] ICI=n310
+ S=n309 ICO=n307 CO=n308
XU670 CMPR42X1 $PINS A=p14 B=FE_OFN25_register_4__7 C=n341 D=n337 ICI=n338
+ S=n335 ICO=n333 CO=n334
XU671 CMPR42X1 $PINS A=n331 B=FE_OFN5745_register_4__14 C=p11 D=n327 ICI=n328
+ S=n325 ICO=n323 CO=n324
XU672 XNOR2X1 $PINS A=p8 B=FE_OFN6072_n6728 Y=n327
XU673 OR2XL $PINS A=p7 B=FE_RN_5 Y=n331
XU674 XNOR2X1 $PINS A=_register_4_8 B=p7 Y=n367
XU675 CMPR42X1 $PINS A=p5 B=FE_OFN5872_register_4__10 C=a[7] D=_register_4_14
+ ICI=n361 S=n360 ICO=n358 CO=n359
XU677 CMPR42X1 $PINS A=n326 B=FE_OFN92_register_4__7 C=FE_OFN80_register_4__10
+ D=n322 ICI=n323 S=n320 ICO=n318 CO=n319
XU678 OR2XL $PINS A=p8 B=FE_OFN6072_n6728 Y=n326
XU679 CMPR42X1 $PINS A=p17 B=FE_OFN594_n4937 C=FE_OFN5865_register_4__11 D=n357
+ ICI=n358 S=n355 ICO=n353 CO=n354
XU680 CMPR42X1 $PINS A=_register_4_8 B=n321 C=_register_4_11 D=n317 ICI=n318
+ S=n315 ICO=n313 CO=n314
XU681 OR2XL $PINS A=a[15] B=p19 Y=n321
XU682 CMPR42X1 $PINS A=FE_OFN6072_n6728 B=p14 C=a[9] D=n316 ICI=n313 S=n312
+ ICO=n310 CO=n311
XU683 OR2XL $PINS A=FE_OFN5740_register_4__19 B=FE_OFN5910_register_4__16
+ Y=n316
XU684 CMPR42X1 $PINS A=p8 B=a[9] C=p15 D=p4 ICI=n366 S=n363 ICO=n361 CO=n362
XU685 OR2XL $PINS A=_register_4_8 B=p7 Y=n366
XU686 XOR3X2 $PINS A=n35 B=FE_OFN5740_register_4__19 C=a[18] Y=product[34]
XU687 ADDFX2 $PINS A=a[15] B=p6 CI=p20 S=n337 CO=n336
XU688 CMPR42X1 $PINS A=FE_OFN5748_register_4__13 B=FE_OFN81_register_4__8
+ C=n332 D=n336 ICI=n333 S=n330 ICO=n328 CO=n329
XU689 ADDFX2 $PINS A=FE_OFN5910_register_4__16 B=FE_OFN5748_register_4__13
+ CI=n302 S=n299 CO=n298
XU690 OR2XL $PINS A=p14 B=p17 Y=n302
XU691 CMPR32X1 $PINS A=p19 B=FE_OFN98_n6728 C=a[15] S=n295 CO=n294
XU692 CMPR42X1 $PINS A=FE_OFN5745_register_4__14 B=FE_OFN5740_register_4__19
+ C=p13 D=p15 ICI=n307 S=n306 ICO=n304 CO=n305
XU693 ADDFX2 $PINS A=_register_4_14 B=n304 CI=n303 S=n301 CO=n300
XU694 XNOR2X1 $PINS A=p14 B=p17 Y=n303
XU695 ADDHXL $PINS A=FE_OFN6072_n6728 B=p20 S=n291 CO=n290
XU696 XNOR2XL $PINS A=n250 B=n4937 Y=product[3]
XU697 AND2X1 $PINS A=n4937 B=FE_RN_6 Y=n498
XU698 ADDFX2 $PINS A=FE_OFN62_register_4__18 B=n4937 CI=a[6] S=n342 CO=n341
XU699 NOR2XL $PINS A=n4937 B=a[2] Y=n248
XU700 ADDFX2 $PINS A=p8 B=n4937 CI=FE_OFN80_register_4__10 S=n371 CO=n370
XU701 XOR2X1 $PINS A=n4937 B=FE_RN_6 Y=n377
XU481 OR2X2 $PINS A=n325 B=n329 Y=n562
XU702 INVX1 $PINS A=n562 Y=n134
XU703 AOI2BB1X1 $PINS A0N=n134 A1N=n142 B0=n564 Y=n563
XU704 INVX1 $PINS A=n563 Y=n133
XU705 INVX1 $PINS A=n135 Y=n564
.ENDS

.SUBCKT CONV_DW01_sub_19 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI DIFF[35] DIFF[34]
+ DIFF[33] DIFF[32] DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO p1
*.CONNECT DIFF[0] B[0]
XFE_RC_651_0 OAI21X1 $PINS A0=n61 A1=n42 B0=n44 Y=n41
XFE_OFC1490_n41 CLKINVX3 $PINS A=n41 Y=FE_DBTN169_n41
XFE_DBTC185_N730 INVX1 $PINS A=B[23] Y=FE_DBTN185_N730
XFE_DBTC170_n38 INVX1 $PINS A=n38 Y=FE_DBTN170_n38
XU209 AOI21X1 $PINS A0=n234 A1=n66 B0=n236 Y=n61
XU177 NOR2X1 $PINS A=B[27] B=B[26] Y=n38
XU146 INVX1 $PINS A=B[32] Y=n237
XU147 XOR2X1 $PINS A=n71 B=B[17] Y=DIFF[17]
XU150 XNOR2X1 $PINS A=n19 B=B[31] Y=DIFF[31]
XU151 XOR2X1 $PINS A=n50 B=n235 Y=DIFF[24]
XU152 OAI22XL $PINS A0=FE_DBTN169_n41 A1=n14 B0=n239 B1=n221 Y=n13
XU154 NAND2X1 $PINS A=n229 B=n47 Y=n50
XU155 OR2X2 $PINS A=n61 B=B[21] Y=n58
XU156 OAI31X1 $PINS A0=B[30] A1=FE_DBTN169_n41 A2=n28 B0=n21 Y=n19
XU157 OR2X2 $PINS A=FE_DBTN170_n38 B=B[29] Y=n28
XU159 OR2X2 $PINS A=n74 B=B[16] Y=n71
XU161 XNOR2X1 $PINS A=n88 B=B[10] Y=DIFF[10]
XU162 XOR2X1 $PINS A=n93 B=B[8] Y=DIFF[8]
XU163 XNOR2X1 $PINS A=n76 B=B[15] Y=DIFF[15]
XU164 NOR2X2 $PINS A=n67 B=n74 Y=n66
XU165 INVX1 $PINS A=n66 Y=n228
XU166 XNOR2X1 $PINS A=n13 B=B[32] Y=DIFF[32]
XU167 OR2X2 $PINS A=n28 B=n239 Y=n14
XU168 NAND2X1 $PINS A=n82 B=n232 Y=n79
XU169 INVX1 $PINS A=B[13] Y=n232
XU170 NAND2X1 $PINS A=n98 B=n243 Y=n96
XU171 INVX1 $PINS A=n74 Y=n227
XU172 NOR2X1 $PINS A=B[17] B=B[16] Y=n70
XU173 NOR2X1 $PINS A=B[4] B=B[3] Y=n100
XU174 NOR2X1 $PINS A=n99 B=B[5] Y=n98
XU175 NAND2BX1 $PINS AN=B[18] B=n70 Y=n67
XU176 INVX1 $PINS A=n78 Y=n226
XU179 XNOR2X1 $PINS A=n227 B=B[16] Y=DIFF[16]
XU180 NOR2X1 $PINS A=n226 B=B[14] Y=n76
XU181 INVX1 $PINS A=B[20] Y=n236
XU182 NOR2X1 $PINS A=B[21] B=B[22] Y=n57
XU183 XOR2X1 $PINS A=B[19] B=n228 Y=DIFF[19]
XU184 NOR2BX1 $PINS AN=n57 B=B[23] Y=n47
XU185 INVX1 $PINS A=n61 Y=n229
XU186 OAI21XL $PINS A0=FE_DBTN169_n41 A1=n28 B0=n221 Y=n23
XU187 NOR2X1 $PINS A=B[11] B=B[12] Y=n82
XU188 NOR2X1 $PINS A=n79 B=n86 Y=n78
XU189 INVX1 $PINS A=n86 Y=n241
XU191 NOR2X1 $PINS A=n91 B=n96 Y=n90
XU192 OAI21XL $PINS A0=FE_DBTN169_n41 A1=FE_DBTN170_n38 B0=B[28] Y=n32
XU193 NAND2X1 $PINS A=n87 B=n90 Y=n86
XU194 NOR2X1 $PINS A=B[10] B=B[9] Y=n87
XU195 NOR2X1 $PINS A=B[2] B=n104 Y=n103
XU196 INVX1 $PINS A=B[6] Y=n243
XU197 NAND2X1 $PINS A=n57 B=FE_DBTN185_N730 Y=n42
XU198 AND2X2 $PINS A=B[25] B=B[24] Y=n44
XU200 INVX1 $PINS A=B[7] Y=n244
XU202 OR2X2 $PINS A=B[29] B=B[28] Y=n221
XU203 NOR2X1 $PINS A=n8 B=B[33] Y=n7
XU204 XOR2X1 $PINS A=n34 B=B[28] Y=DIFF[28]
XU205 NOR2X1 $PINS A=FE_DBTN169_n41 B=FE_DBTN170_n38 Y=n34
XU207 NOR2X1 $PINS A=FE_DBTN169_n41 B=B[26] Y=n39
XU208 OR2X2 $PINS A=n221 B=B[30] Y=n21
XU210 OR2X2 $PINS A=n228 B=B[19] Y=n224
XU211 XOR2X1 $PINS A=FE_DBTN169_n41 B=B[26] Y=DIFF[26]
XU212 NOR2X1 $PINS A=n11 B=n221 Y=n10
XU213 NAND2BX1 $PINS AN=B[1] B=p1 Y=n104
XU214 NAND2BX1 $PINS AN=n225 B=n78 Y=n74
XU215 INVXL $PINS A=B[19] Y=n234
XU216 NOR2XL $PINS A=n246 B=B[3] Y=n101
XU217 XOR2X1 $PINS A=B[9] B=n240 Y=DIFF[9]
XU218 XOR2X1 $PINS A=n224 B=n236 Y=DIFF[20]
XU219 XOR2X1 $PINS A=B[3] B=n246 Y=DIFF[3]
XU220 NOR2XL $PINS A=n240 B=B[9] Y=n88
XU221 NAND2XL $PINS A=n241 B=n245 Y=n83
XU222 INVXL $PINS A=B[11] Y=n245
XU223 XNOR2XL $PINS A=n98 B=B[6] Y=DIFF[6]
XU224 NAND2XL $PINS A=n227 B=n70 Y=n69
XU225 OR2X2 $PINS A=B[15] B=B[14] Y=n225
XU226 XNOR2XL $PINS A=n46 B=B[25] Y=DIFF[25]
XU228 NAND2XL $PINS A=n229 B=n57 Y=n54
XU229 INVXL $PINS A=n255 Y=n239
XU230 NAND2BX1 $PINS AN=B[8] B=n244 Y=n91
XU231 NAND2XL $PINS A=n242 B=n244 Y=n93
XU232 XOR2X1 $PINS A=n8 B=B[33] Y=DIFF[33]
XU233 INVX1 $PINS A=n96 Y=n242
XU235 NAND2X1 $PINS A=n255 B=n237 Y=n11
XU236 INVX1 $PINS A=n103 Y=n246
XU237 INVX1 $PINS A=n90 Y=n240
XU238 INVXL $PINS A=B[24] Y=n235
XU239 XNOR2X1 $PINS A=n229 B=B[21] Y=DIFF[21]
XU240 XNOR2X1 $PINS A=n241 B=B[11] Y=DIFF[11]
XU241 XNOR2X1 $PINS A=B[7] B=n242 Y=DIFF[7]
XU242 AOI21X1 $PINS A0=n229 A1=n47 B0=n235 Y=n46
XU243 XOR2X1 $PINS A=n58 B=B[22] Y=DIFF[22]
XU244 XOR2X1 $PINS A=n69 B=B[18] Y=DIFF[18]
XU245 XOR2X1 $PINS A=n81 B=B[13] Y=DIFF[13]
XU246 NAND2X1 $PINS A=n241 B=n82 Y=n81
XU247 XOR2X1 $PINS A=n83 B=B[12] Y=DIFF[12]
XU249 XNOR2X1 $PINS A=B[1] B=p1 Y=DIFF[1]
XU250 XOR2X1 $PINS A=n99 B=B[5] Y=DIFF[5]
XU251 XOR2X1 $PINS A=B[2] B=n104 Y=DIFF[2]
XU252 NAND2X1 $PINS A=n100 B=n103 Y=n99
XU254 XNOR2X1 $PINS A=n7 B=B[34] Y=DIFF[34]
XU255 XNOR2X1 $PINS A=n101 B=B[4] Y=DIFF[4]
XU256 INVX1 $PINS A=n222 Y=DIFF[35]
XU257 NOR2BX1 $PINS AN=n7 B=B[34] Y=n222
XU148 XNOR2X1 $PINS A=n226 B=n248 Y=DIFF[14]
XU149 INVX1 $PINS A=B[14] Y=n248
XU160 AOI2BB1X1 $PINS A0N=n250 A1N=FE_DBTN169_n41 B0=n10 Y=n8
XU206 OR2X2 $PINS A=n11 B=n28 Y=n250
XU227 XNOR2X1 $PINS A=n54 B=FE_DBTN185_N730 Y=DIFF[23]
XU260 XOR2X1 $PINS A=n23 B=n254 Y=DIFF[30]
XU261 INVX1 $PINS A=B[30] Y=n254
XU262 NOR2X1 $PINS A=B[30] B=B[31] Y=n255
XU264 XOR2X1 $PINS A=n32 B=n257 Y=DIFF[29]
XU265 INVX1 $PINS A=B[29] Y=n257
XU266 XOR2X1 $PINS A=n39 B=n258 Y=DIFF[27]
XU267 INVX1 $PINS A=B[27] Y=n258
.ENDS

.SUBCKT CONV_DW_mult_uns_23_0 a[35] a[34] a[33] a[32] a[31] a[30] a[29] a[28]
+ a[27] a[26] a[25] a[24] a[23] a[22] a[21] a[20] a[19] a[18] a[17] a[16] a[15]
+ a[14] a[13] a[12] a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1]
+ a[0] b[13] b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1]
+ b[0] product[49] product[48] product[47] product[46] product[45] product[44]
+ product[43] product[42] product[41] product[40] product[39] product[38]
+ product[37] product[36] product[35] product[34] product[33] product[32]
+ product[31] product[30] product[29] product[28] product[27] product[26]
+ product[25] product[24] product[23] product[22] product[21] product[20]
+ product[19] product[18] product[17] product[16] product[15] product[14]
+ product[13] product[12] product[11] product[10] product[9] product[8]
+ product[7] product[6] product[5] product[4] product[3] product[2] product[1]
+ product[0] n4908 n4907 n4906 n4905 n6739 n5280 n5286 p1 FE_OFN60_n4983 N965
+ p_2 p_3 p_4 FE_OFN84_n FE_OFN5855_FE_DBTN21_N1711
*.CONNECT FE_RN_3 a[0]
XFE_OFC2231_n158 INVX1 $PINS A=n158 Y=n156
XFE_OFC2229_n4906 INVX1 $PINS A=p_4 Y=FE_OFN6156_n4906
XFE_OFC2220_n4905 INVX1 $PINS A=p_2 Y=FE_OFN6149_n4905
XFE_OFC2143_n186 INVX4 $PINS A=n186 Y=FE_OFN6100_n186
XFE_OFC2141_n186 BUFX3 $PINS A=n186 Y=n185
XFE_OFC2117_n159 CLKINVX3 $PINS A=n159 Y=n157
XFE_OFC2098_n4908 INVX1 $PINS A=n4908 Y=FE_OFN6078_n4908
XFE_OFC2097_n4908 INVX1 $PINS A=n4908 Y=FE_OFN6077_n4908
XFE_OFC2095_n4908 INVX1 $PINS A=n4908 Y=FE_RN_2
XFE_OFC2069_n133 INVX1 $PINS A=n133 Y=n131
XFE_OFC1860_FE_OFN409_n4971 INVX1 $PINS A=n416 Y=FE_OFN5917_FE_OFN409_n4971
XFE_OFC1858_FE_OFN409_n4971 INVX1 $PINS A=a[7] Y=n416
XFE_OFC1654_n5280 INVX1 $PINS A=n5280 Y=FE_OFN5809_n5280
XFE_OFC1653_n5280 INVX1 $PINS A=n5280 Y=FE_RN_1
XFE_OFC1459_n207 CLKINVX3 $PINS A=n206 Y=FE_OFN5705_n207
XFE_OFC1458_n207 INVX4 $PINS A=n207 Y=n206
XFE_OFC1362_FE_OFN5416_r2240_DIFF_9 INVX1 $PINS A=a[9] Y=n414
XFE_OFC1350_FE_OFN549_n4975 INVX1 $PINS A=a[15] Y=n408
XFE_OFC959_r2240_DIFF_17 INVX1 $PINS A=a[17] Y=n406
XFE_OFC916_r2240_DIFF_11 INVX1 $PINS A=a[11] Y=n412
XFE_OFC654_r2240_DIFF_4 INVX1 $PINS A=a[4] Y=n419
XFE_OFC191_n122 INVX1 $PINS A=n122 Y=FE_DBTN168_n122
XFE_OFC186_n532 INVX1 $PINS A=n532 Y=n134
XU62 OAI21X1 $PINS A0=n98 A1=n78 B0=n79 Y=n77
XU145 NOR2X2 $PINS A=n151 B=n144 Y=n142
XU149 NOR2X2 $PINS A=n327 B=n324 Y=n144
XU161 XNOR2X4 $PINS A=n164 B=n15 Y=product[21]
XU173 NOR2X2 $PINS A=n334 B=n339 Y=n162
XU207 OAI21X4 $PINS A0=n187 A1=FE_OFN5705_n207 B0=n188 Y=n186
XU210 NOR2X2 $PINS A=n194 B=n191 Y=n189
XU214 NOR2X2 $PINS A=n358 B=n363 Y=n191
XU220 NOR2X1 $PINS A=n364 B=n369 Y=n194
XU240 AOI21X1 $PINS A0=n208 A1=n227 B0=n209 Y=n207
XU241 NOR2X1 $PINS A=n213 B=n210 Y=n208
XU245 NOR2X1 $PINS A=n382 B=n385 Y=n210
XU265 NOR2X1 $PINS A=n390 B=n393 Y=n224
XU269 OAI21X1 $PINS A0=n245 A1=n228 B0=n229 Y=n227
XU296 AOI21X2 $PINS A0=n246 A1=n254 B0=n247 Y=n245
XU350 ADDFX2 $PINS A=n338 B=n341 CI=n336 S=n334 CO=n333
XU359 ADDFX2 $PINS A=n356 B=n359 CI=n354 S=n352 CO=n351
XU362 ADDFHX2 $PINS A=n362 B=n365 CI=n360 S=n358 CO=n357
XU365 ADDFHX2 $PINS A=n368 B=n371 CI=n366 S=n364 CO=n363
XU423 OR2X2 $PINS A=n312 B=n315 Y=n516
XU424 ADDFHX1 $PINS A=n408 B=n317 CI=n314 S=n312 CO=n311
XU425 NOR2X2 $PINS A=n183 B=n180 Y=n178
XU426 OAI21X1 $PINS A0=FE_OFN6100_n186 A1=n136 B0=n137 Y=n135
XU427 AOI21X1 $PINS A0=n157 A1=n142 B0=n143 Y=n137
XU429 OR2X2 $PINS A=n394 B=n395 Y=n513
XU431 AOI21X1 $PINS A0=n121 A1=n516 B0=n108 Y=n106
XU432 NAND2X1 $PINS A=n167 B=n170 Y=n16
XU433 NOR2X1 $PINS A=n242 B=n237 Y=n235
XU434 OAI21X2 $PINS A0=FE_OFN6100_n186 A1=n165 B0=n166 Y=n164
XU435 AOI22X2 $PINS A0=n340 A1=n345 B0=n167 B1=n179 Y=n166
XU436 NAND2BX1 $PINS AN=n224 B=n514 Y=n213
XU437 XNOR2X4 $PINS A=n193 B=n19 Y=product[17]
XU439 AOI21X2 $PINS A0=n189 A1=n198 B0=n190 Y=n188
XU440 NAND2X1 $PINS A=n390 B=n393 Y=n225
XU441 ADDFX2 $PINS A=p_3 B=FE_OFN5855_FE_DBTN21_N1711 CI=n392 S=n390 CO=n389
XU442 NAND2X1 $PINS A=n157 B=n149 Y=n509
XU444 AND2X2 $PINS A=n509 B=n152 Y=n148
XU445 INVX1 $PINS A=n151 Y=n149
XU447 ADDFHX1 $PINS A=n350 B=n353 CI=n348 S=n346 CO=n345
XU448 XNOR2X2 $PINS A=n135 B=n524 Y=product[24]
XU449 INVX1 $PINS A=n169 Y=n167
XU451 OAI21XL $PINS A0=FE_OFN6100_n186 A1=n158 B0=n159 Y=n153
XU454 OAI21X4 $PINS A0=n180 A1=n184 B0=n181 Y=n179
XU455 NOR2X2 $PINS A=n346 B=n351 Y=n180
XU456 NAND2X1 $PINS A=n178 B=n160 Y=n158
XU457 OAI21X2 $PINS A0=n159 A1=n101 B0=n102 Y=n100
XU458 NOR2X1 $PINS A=n158 B=n101 Y=n99
XU459 NAND2X1 $PINS A=n142 B=n103 Y=n101
XU460 XNOR2X2 $PINS A=n196 B=n521 Y=product[16]
XU461 XNOR2X1 $PINS A=n153 B=n525 Y=product[22]
XU462 INVX1 $PINS A=n254 Y=n253
XU463 OAI21XL $PINS A0=n257 A1=n255 B0=n256 Y=n254
XU464 XNOR2X1 $PINS A=a[3] B=a[4] Y=n402
XU465 CLKINVX3 $PINS A=n227 Y=n226
XU466 OAI21X1 $PINS A0=n98 A1=n89 B0=n86 Y=n84
XU468 ADDFHX1 $PINS A=a[3] B=p_4 CI=n6739 S=n362 CO=n361
XU471 NOR2X1 $PINS A=a[3] B=a[2] Y=n255
XU472 ADDFX2 $PINS A=p_2 B=n411 CI=n361 S=n354 CO=n353
XU473 ADDFX2 $PINS A=a[18] B=FE_OFN84_n CI=n406 S=n306 CO=n305
XU474 ADDFHX2 $PINS A=n344 B=n347 CI=n342 S=n340 CO=n339
XU475 ADDFX2 $PINS A=n405 B=n321 CI=n318 S=n316 CO=n315
XU476 NAND2X1 $PINS A=n400 B=n401 Y=n249
XU477 NOR2X1 $PINS A=n402 B=FE_OFN5855_FE_DBTN21_N1711 Y=n251
XU478 NAND2X1 $PINS A=n402 B=FE_OFN5855_FE_DBTN21_N1711 Y=n252
XU481 NAND2X1 $PINS A=n340 B=n345 Y=n170
XU482 XNOR2X1 $PINS A=n212 B=n23 Y=product[13]
XU483 XOR2X1 $PINS A=n239 B=n27 Y=product[9]
XU484 XNOR2X1 $PINS A=n124 B=n526 Y=product[25]
XU486 NOR2X1 $PINS A=n398 B=n399 Y=n242
XU487 NAND2BXL $PINS AN=n183 B=n184 Y=n18
XU488 XNOR2X1 $PINS A=n4 B=n59 Y=product[32]
XU489 AOI22X1 $PINS A0=n236 A1=n513 B0=n394 B1=n395 Y=n229
XU490 NOR2X2 $PINS A=n340 B=n345 Y=n169
XU491 XNOR2X2 $PINS A=n84 B=n7 Y=product[29]
XU492 NAND2BX1 $PINS AN=n191 B=n192 Y=n19
XU493 NOR2X1 $PINS A=n310 B=n311 Y=n96
XU494 XNOR3X2 $PINS A=n257 B=a[3] C=a[2] Y=product[5]
XU495 NAND2BX1 $PINS AN=n242 B=n512 Y=n28
XU496 NAND2X1 $PINS A=n310 B=n311 Y=n97
XU497 XOR2X1 $PINS A=n346 B=n351 Y=n523
XU498 XOR2X1 $PINS A=a[1] B=FE_RN_3 Y=product[3]
XU499 AND2X2 $PINS A=n511 B=n512 Y=n239
XU500 NAND2X1 $PINS A=n131 B=FE_DBTN168_n122 Y=n116
XU502 NOR2BX1 $PINS AN=n195 B=n194 Y=n521
XU503 NAND2BX1 $PINS AN=n224 B=n225 Y=n25
XU504 NAND2BX1 $PINS AN=n237 B=n238 Y=n27
XU505 NAND2BX1 $PINS AN=n46 B=n47 Y=n3
XU506 NAND2BXL $PINS AN=n162 B=n163 Y=n15
XU507 NAND2X1 $PINS A=n364 B=n369 Y=n195
XU508 NOR2X1 $PINS A=n309 B=n308 Y=n93
XU509 AOI21X1 $PINS A0=n244 A1=n235 B0=n236 Y=n234
XU510 INVX1 $PINS A=n245 Y=n244
XU511 NAND2X1 $PINS A=n202 B=n205 Y=n22
XU512 INVX1 $PINS A=n204 Y=n202
XU513 NAND2BX1 $PINS AN=n158 B=n149 Y=n147
XU514 OAI21X1 $PINS A0=n162 A1=n170 B0=n163 Y=n161
XU515 AOI22X1 $PINS A0=a[2] A1=a[1] B0=n515 B1=n262 Y=n257
XU516 NOR2X1 $PINS A=n396 B=n397 Y=n237
XU517 XNOR2X1 $PINS A=n370 B=n375 Y=n21
XU518 NAND2X1 $PINS A=n334 B=n339 Y=n163
XU519 NAND2BX1 $PINS AN=n96 B=n97 Y=n9
XU520 AND2X1 $PINS A=n145 B=n276 Y=n529
XU521 NAND2X1 $PINS A=n398 B=n399 Y=n512
XU522 XOR3X2 $PINS A=n402 B=FE_OFN5855_FE_DBTN21_N1711 C=n254 Y=product[6]
XU523 OAI221XL $PINS A0=n141 A1=n116 B0=n134 B1=n122 C0=n123 Y=n115
XU524 INVX1 $PINS A=n143 Y=n141
XU525 NAND2BX1 $PINS AN=n75 B=n76 Y=n527
XU526 OAI21XL $PINS A0=n75 A1=n83 B0=n76 Y=n74
XU527 NAND2X2 $PINS A=n352 B=n357 Y=n184
XU528 OR2X2 $PINS A=n245 B=n242 Y=n511
XU529 NAND2X1 $PINS A=n394 B=n395 Y=n233
XU530 NOR2X1 $PINS A=n140 B=n116 Y=n114
XU531 INVX1 $PINS A=n142 Y=n140
XU532 NAND2BX1 $PINS AN=n248 B=n249 Y=n29
XU533 INVX1 $PINS A=n110 Y=n108
XU534 AOI22X1 $PINS A0=n302 A1=n303 B0=n62 B1=n70 Y=n61
XU535 NOR2X2 $PINS A=n352 B=n357 Y=n183
XU536 AOI22X1 $PINS A0=n306 A1=n307 B0=n80 B1=n92 Y=n79
XU537 NOR2BX1 $PINS AN=n4908 B=a[18] Y=n46
XU538 NAND2BX1 $PINS AN=n210 B=n211 Y=n23
XU539 NAND2X1 $PINS A=n156 B=n142 Y=n136
XU540 XNOR2X2 $PINS A=n95 B=n8 Y=product[28]
XU541 INVX1 $PINS A=a[18] Y=n405
XU543 ADDFX2 $PINS A=a[4] B=a[15] CI=n416 S=n356 CO=n355
XU544 ADDFX2 $PINS A=a[18] B=n5280 CI=n410 S=n322 CO=n321
XU545 ADDFHX1 $PINS A=n5286 B=a[4] CI=n422 S=n400 CO=n399
XU546 ADDFX2 $PINS A=n380 B=n383 CI=n378 S=n376 CO=n375
XU547 ADDFX2 $PINS A=FE_OFN60_n4983 B=n4907 CI=n420 S=n378 CO=n377
XU548 INVX1 $PINS A=n205 Y=n203
XU549 ADDFX2 $PINS A=n4908 B=n4905 CI=n405 S=n304 CO=n303
XU550 NOR2X1 $PINS A=n96 B=n93 Y=n91
XU552 OAI21X1 $PINS A0=n199 A1=n205 B0=n200 Y=n198
XU553 NOR2X1 $PINS A=n199 B=n204 Y=n197
XU554 NOR2X1 $PINS A=n370 B=n375 Y=n199
XU555 NAND2XL $PINS A=n301 B=n405 Y=n58
XU556 NOR2X1 $PINS A=n105 B=n133 Y=n103
XU557 AOI21XL $PINS A0=n157 A1=n114 B0=n115 Y=n113
XU559 ADDFHX2 $PINS A=n5286 B=p_2 CI=n4907 S=n350 CO=n349
XU560 XNOR2X1 $PINS A=n66 B=n5 Y=product[31]
XU561 NAND2X2 $PINS A=n189 B=n197 Y=n187
XU563 INVX1 $PINS A=a[13] Y=n410
XU564 ADDFX2 $PINS A=a[13] B=n414 CI=n379 S=n372 CO=n371
XU565 ADDFX2 $PINS A=a[8] B=a[7] CI=n419 S=n394 CO=n393
XU566 ADDFX2 $PINS A=a[6] B=a[17] CI=n414 S=n344 CO=n343
XU567 ADDFX2 $PINS A=n6739 B=n391 CI=n388 S=n386 CO=n385
XU569 OAI21XL $PINS A0=n86 A1=n71 B0=n72 Y=n70
XU570 INVX1 $PINS A=n91 Y=n89
XU571 INVX1 $PINS A=n92 Y=n86
XU572 NOR2X1 $PINS A=n376 B=n381 Y=n204
XU573 NAND2X1 $PINS A=n376 B=n381 Y=n205
XU574 NAND2X1 $PINS A=n370 B=n375 Y=n200
XU575 NAND2X1 $PINS A=n235 B=n513 Y=n228
XU576 NAND2X1 $PINS A=n178 B=n167 Y=n165
XU577 NAND2X1 $PINS A=n319 B=n316 Y=n123
XU578 XOR2X1 $PINS A=n98 B=n9 Y=product[27]
XU579 XNOR2X1 $PINS A=n32 B=n262 Y=product[4]
XU580 OAI21X1 $PINS A0=n98 A1=n96 B0=n97 Y=n95
XU581 AOI21X1 $PINS A0=n92 A1=n530 B0=n52 Y=n50
XU582 NAND2X1 $PINS A=n91 B=n530 Y=n49
XU583 INVX1 $PINS A=a[20] Y=n403
XU584 OAI21XL $PINS A0=n50 A1=n46 B0=n47 Y=n45
XU585 XOR2X2 $PINS A=n146 B=n529 Y=product[23]
XU587 OR2X2 $PINS A=n386 B=n389 Y=n514
XU589 NAND2X1 $PINS A=n396 B=n397 Y=n238
XU590 ADDFX2 $PINS A=a[6] B=n5286 CI=n421 S=n398 CO=n397
XU591 ADDFX2 $PINS A=a[7] B=a[6] CI=n420 S=n396 CO=n395
XU592 NOR2X1 $PINS A=n319 B=n316 Y=n122
XU594 ADDFX2 $PINS A=a[20] B=FE_OFN60_n4983 CI=FE_RN_2 S=n314 CO=n313
XU595 ADDFX2 $PINS A=a[20] B=a[17] CI=FE_OFN6077_n4908 S=n302 CO=n301
XU596 NAND2XL $PINS A=n309 B=n308 Y=n94
XU597 OAI21X4 $PINS A0=FE_OFN6100_n186 A1=n172 B0=n177 Y=n171
XU598 XOR2X1 $PINS A=n226 B=n25 Y=product[11]
XU599 OR2XL $PINS A=a[2] B=a[1] Y=n515
XU600 OAI21XL $PINS A0=FE_OFN6100_n186 A1=n125 B0=n126 Y=n124
XU601 NAND2XL $PINS A=n91 B=n80 Y=n78
XU602 OAI21X2 $PINS A0=n144 A1=n152 B0=n145 Y=n143
XU603 NOR2X1 $PINS A=n140 B=n133 Y=n127
XU604 AOI21X2 $PINS A0=n206 A1=n202 B0=n203 Y=n201
XU605 INVX1 $PINS A=n178 Y=n172
XU606 OAI21X1 $PINS A0=FE_OFN6100_n186 A1=n147 B0=n148 Y=n146
XU607 INVXL $PINS A=n144 Y=n276
XU608 ADDFHX1 $PINS A=a[2] B=a[13] CI=p_3 S=n368 CO=n367
XU609 ADDFX2 $PINS A=a[15] B=n412 CI=n367 S=n360 CO=n359
XU611 INVX1 $PINS A=a[2] Y=n421
XU612 INVX1 $PINS A=a[3] Y=n420
XU613 NOR2X1 $PINS A=n82 B=n75 Y=n73
XU614 ADDFX2 $PINS A=a[1] B=n419 CI=a[12] S=n374 CO=n373
XU617 ADDFX2 $PINS A=a[17] B=n410 CI=n355 S=n348 CO=n347
XU619 ADDFX2 $PINS A=n4908 B=a[11] CI=FE_OFN6156_n4906 S=n318 CO=n317
XU620 ADDFX2 $PINS A=n416 B=n387 CI=n384 S=n382 CO=n381
XU621 OR2X2 $PINS A=a[3] B=a[4] Y=n401
XU622 ADDFX2 $PINS A=n403 B=n322 CI=n325 S=n320 CO=n319
XU623 NAND2X1 $PINS A=n346 B=n351 Y=n181
XU624 NAND2X1 $PINS A=n382 B=n385 Y=n211
XU625 INVX1 $PINS A=n264 Y=n262
XU626 NOR2X1 $PINS A=n304 B=n305 Y=n75
XU627 AOI21X1 $PINS A0=n157 A1=n127 B0=n128 Y=n126
XU629 ADDFX2 $PINS A=n337 B=n335 CI=n330 S=n328 CO=n327
XU630 NOR2X2 $PINS A=n169 B=n162 Y=n160
XU632 NAND2X1 $PINS A=n312 B=n315 Y=n110
XU633 OAI21X1 $PINS A0=n226 A1=n224 B0=n225 Y=n219
XU634 XOR2X1 $PINS A=n26 B=n234 Y=product[10]
XU635 XNOR2X1 $PINS A=n41 B=n2 Y=product[34]
XU636 NAND2X1 $PINS A=FE_DBTN168_n122 B=n123 Y=n526
XU637 NAND2X1 $PINS A=n127 B=n156 Y=n125
XU638 NAND2X1 $PINS A=n328 B=n333 Y=n152
XU640 INVX1 $PINS A=n225 Y=n223
XU641 INVX1 $PINS A=n179 Y=n177
XU642 OR2XL $PINS A=n403 B=n4908 Y=n517
XU643 OAI21XL $PINS A0=n93 A1=n97 B0=n94 Y=n92
XU644 NOR2X1 $PINS A=n323 B=n320 Y=n133
XU645 NOR2X1 $PINS A=n328 B=n333 Y=n151
XU646 NOR2X1 $PINS A=n306 B=n307 Y=n82
XU648 XNOR2X1 $PINS A=a[8] B=a[9] Y=n392
XU649 ADDFHX1 $PINS A=a[20] B=n4908 CI=a[8] S=n332 CO=n331
XU650 OAI21X4 $PINS A0=FE_OFN6100_n186 A1=n183 B0=n184 Y=n182
XU653 NAND2X1 $PINS A=n358 B=n363 Y=n192
XU654 ADDFHX1 $PINS A=a[18] B=FE_OFN6156_n4906 CI=n349 S=n342 CO=n341
XU655 AOI21X1 $PINS A0=n143 A1=n103 B0=n104 Y=n102
XU656 OAI21XL $PINS A0=n105 A1=n134 B0=n106 Y=n104
XU657 INVX1 $PINS A=n218 Y=n216
XU658 ADDFHX1 $PINS A=n5280 B=a[9] CI=n422 S=n388 CO=n387
XU659 OAI21X1 $PINS A0=n196 A1=n194 B0=n195 Y=n193
XU660 NOR2X1 $PINS A=n248 B=n251 Y=n246
XU661 NOR2X1 $PINS A=n400 B=n401 Y=n248
XU662 XOR2X2 $PINS A=n182 B=n523 Y=product[19]
XU663 OAI21X1 $PINS A0=n214 A1=n210 B0=n211 Y=n209
XU664 AOI21X4 $PINS A0=n99 A1=n185 B0=n100 Y=n98
XU665 AOI21X2 $PINS A0=n206 A1=n197 B0=n198 Y=n196
XU666 OAI21XL $PINS A0=n226 A1=n213 B0=n214 Y=n212
XU667 INVX1 $PINS A=FE_OFN60_n4983 Y=n411
XU668 XOR2X2 $PINS A=FE_OFN6100_n186 B=n18 Y=product[18]
XU669 AOI21X4 $PINS A0=n160 A1=n179 B0=n161 Y=n159
XU670 OAI21XL $PINS A0=n253 A1=n251 B0=n252 Y=n250
XU671 OAI21XL $PINS A0=n248 A1=n252 B0=n249 Y=n247
XU672 XNOR2X4 $PINS A=n171 B=n16 Y=product[20]
XU673 XOR2X1 $PINS A=n201 B=n21 Y=product[15]
XU674 NAND2X1 $PINS A=n386 B=n389 Y=n218
XU675 XOR2X1 $PINS A=n219 B=n520 Y=product[12]
XU676 ADDFX2 $PINS A=FE_OFN5917_FE_OFN409_n4971 B=a[18] CI=FE_OFN5809_n5280
+ S=n338 CO=n337
XU677 NAND2X1 $PINS A=a[1] B=N965 Y=n264
XU678 NAND2X1 $PINS A=n304 B=n305 Y=n76
XU679 AOI21X1 $PINS A0=n514 A1=n223 B0=n216 Y=n214
XU680 INVXL $PINS A=n82 Y=n80
XU681 NAND2XL $PINS A=a[2] B=a[1] Y=n261
XU682 AND2X1 $PINS A=n514 B=n218 Y=n520
XU683 NAND2XL $PINS A=n516 B=n110 Y=n522
XU684 NAND2XL $PINS A=n131 B=n134 Y=n524
XU685 NAND2BX1 $PINS AN=n93 B=n94 Y=n8
XU686 NAND2XL $PINS A=n80 B=n83 Y=n7
XU687 AOI21X1 $PINS A0=n55 A1=n74 B0=n56 Y=n54
XU688 NAND2XL $PINS A=FE_OFN6078_n4908 B=a[18] Y=n47
XU689 ADDFX2 $PINS A=n406 B=a[9] CI=n411 S=n326 CO=n325
XU692 NOR2X1 $PINS A=n89 B=n71 Y=n69
XU693 XNOR2X1 $PINS A=n111 B=n522 Y=product[26]
XU694 NAND2XL $PINS A=n149 B=n152 Y=n525
XU695 NAND2XL $PINS A=n44 B=n517 Y=n35
XU696 XNOR2X2 $PINS A=n77 B=n527 Y=product[30]
XU697 NAND2BXL $PINS AN=n57 B=n58 Y=n4
XU698 NAND2BXL $PINS AN=n64 B=n65 Y=n5
XU699 INVXL $PINS A=n64 Y=n62
XU700 AOI21XL $PINS A0=n45 A1=n517 B0=n38 Y=n36
XU701 NAND2XL $PINS A=a[3] B=a[2] Y=n256
XU702 ADDFX2 $PINS A=n377 B=n374 CI=n372 S=n370 CO=n369
XU703 ADDFHX2 $PINS A=FE_OFN6149_n4905 B=n412 CI=n332 S=n330 CO=n329
XU704 NAND2XL $PINS A=n403 B=n4908 Y=n40
XU708 INVX1 $PINS A=n69 Y=n67
XU709 INVX1 $PINS A=n44 Y=n42
XU710 INVX1 $PINS A=n45 Y=n43
XU711 INVX1 $PINS A=n70 Y=n68
XU712 OAI21XL $PINS A0=n191 A1=n195 B0=n192 Y=n190
XU713 INVX1 $PINS A=n74 Y=n72
XU714 NOR2X1 $PINS A=n49 B=n46 Y=n44
XU715 XNOR2X1 $PINS A=n206 B=n22 Y=product[14]
XU716 INVX1 $PINS A=n34 Y=product[35]
XU717 OAI21XL $PINS A0=n98 A1=n35 B0=n36 Y=n34
XU718 XNOR2X1 $PINS A=n48 B=n3 Y=product[33]
XU719 OAI21XL $PINS A0=n98 A1=n49 B0=n50 Y=n48
XU720 NAND2X1 $PINS A=n69 B=n62 Y=n60
XU721 INVX1 $PINS A=n73 Y=n71
XU722 INVX1 $PINS A=n123 Y=n121
XU723 AND2X2 $PINS A=n55 B=n73 Y=n530
XU724 INVX1 $PINS A=n54 Y=n52
XU725 OAI21XL $PINS A0=n57 A1=n65 B0=n58 Y=n56
XU726 NAND2X1 $PINS A=n327 B=n324 Y=n145
XU727 NAND2X1 $PINS A=n515 B=n261 Y=n32
XU728 XNOR2X1 $PINS A=n244 B=n28 Y=product[8]
XU729 NAND2X1 $PINS A=n513 B=n233 Y=n26
XU730 OAI21XL $PINS A0=n98 A1=n67 B0=n68 Y=n66
XU731 OAI21XL $PINS A0=n98 A1=n60 B0=n61 Y=n59
XU732 NAND2X1 $PINS A=n517 B=n40 Y=n2
XU733 OAI21XL $PINS A0=n98 A1=n42 B0=n43 Y=n41
XU734 XNOR2X1 $PINS A=n250 B=n29 Y=product[7]
XU735 NOR2X1 $PINS A=n64 B=n57 Y=n55
XU736 INVX1 $PINS A=n40 Y=n38
XU737 OR2X2 $PINS A=a[8] B=a[9] Y=n391
XU738 NAND2X1 $PINS A=n306 B=n307 Y=n83
XU740 ADDFX2 $PINS A=n331 B=n326 CI=n329 S=n324 CO=n323
XU741 INVX1 $PINS A=a[1] Y=n422
XU742 ADDFX2 $PINS A=n4908 B=n408 CI=n343 S=n336 CO=n335
XU743 NOR2X1 $PINS A=n302 B=n303 Y=n64
XU744 NOR2X1 $PINS A=n301 B=n405 Y=n57
XU745 NAND2X1 $PINS A=n302 B=n303 Y=n65
XU748 ADDFX2 $PINS A=n4905 B=a[13] CI=n313 S=n310 CO=n309
XU749 ADDHXL $PINS A=N965 B=a[11] S=n380 CO=n379
XU750 ADDFX2 $PINS A=n373 B=FE_RN_1 CI=p_4 S=n366 CO=n365
XU751 ADDFX2 $PINS A=a[11] B=n5280 CI=n421 S=n384 CO=n383
XU752 ADDFX2 $PINS A=a[17] B=n4906 CI=FE_OFN6149_n4905 S=n308 CO=n307
XU430 OR2X2 $PINS A=n237 B=n512 Y=n531
XU479 NAND2X1 $PINS A=n531 B=n238 Y=n236
XU588 AND2X2 $PINS A=n323 B=n320 Y=n532
XU628 NAND2X1 $PINS A=FE_DBTN168_n122 B=n516 Y=n105
XU753 OAI2BB1X1 $PINS A0N=n143 A1N=n131 B0=n134 Y=n128
XU754 OAI2BB1X1 $PINS A0N=n185 A1N=n535 B0=n113 Y=n111
XU756 AND2X2 $PINS A=n114 B=n156 Y=n535
.ENDS

.SUBCKT CONV_DW_mult_uns_30_0 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[13] b[12]
+ b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0] product[33]
+ product[32] product[31] product[30] product[29] product[28] product[27]
+ product[26] product[25] product[24] product[23] product[22] product[21]
+ product[20] product[19] product[18] product[17] product[16] product[15]
+ product[14] product[13] product[12] product[11] product[10] product[9]
+ product[8] product[7] product[6] product[5] product[4] product[3] product[2]
+ product[1] product[0] p1 p2 p3 p4 p5 p6 p7 FE_OFN0_register_5__10
+ FE_OFN7_register_5__3 FE_OFN30_register_5__2 FE_OFN31_register_5__9
+ FE_OFN32_register_5__4 FE_OFN37_N1281 FE_OFN36_N1281 FE_OFN50_register_5__8
+ FE_OFN59_register_5__4 FE_OFN332_register_5__4 _register_5_4 FE_OFN100_N1281
*.CONNECT FE_RN_2 a[1]
*.CONNECT product[33] n26
XFE_OFC2114_n205 INVX1 $PINS A=n488 Y=FE_OFN6086_n205
XFE_OFC2113_n205 INVX4 $PINS A=n205 Y=n488
XFE_OFC1911_n130 INVXL $PINS A=n128 Y=FE_OFN5939_n130
XFE_OFC1910_n130 INVX1 $PINS A=n130 Y=n128
XFE_OFC1512_n198 INVX1 $PINS A=n192 Y=FE_OFN5734_n198
XFE_OFC1511_n198 CLKINVX3 $PINS A=n198 Y=n192
XFE_OFC1053_n223 INVX1 $PINS A=n223 Y=n221
XFE_OFC609_n171 INVX1 $PINS A=n171 Y=n169
XFE_OFC516_n136 INVX1 $PINS A=n136 Y=FE_OFN337_n136
XFE_DBTC167_n152 INVX1 $PINS A=n152 Y=FE_DBTN167_n152
XU67 XNOR2X1 $PINS A=n89 B=p1 Y=product[26]
XU68 OAI21XL $PINS A0=n136 A1=n85 B0=n86 Y=n84
XU73 XNOR2X1 $PINS A=n104 B=n2 Y=product[25]
XU74 OAI21XL $PINS A0=n136 A1=n90 B0=n91 Y=n89
XU91 XNOR2X2 $PINS A=n115 B=n3 Y=product[24]
XU133 NOR2X1 $PINS A=n292 B=n287 Y=n134
XU222 OAI21X2 $PINS A0=n488 A1=n202 B0=n203 Y=n201
XU236 NOR2X1 $PINS A=n341 B=n344 Y=n210
XU242 NOR2X2 $PINS A=n345 B=n348 Y=n213
XU246 NOR2X2 $PINS A=n223 B=n218 Y=n216
XU247 OAI21X2 $PINS A0=n218 A1=n224 B0=n219 Y=n217
XU258 NOR2X1 $PINS A=n353 B=n356 Y=n223
XU267 NOR2X2 $PINS A=n357 B=n360 Y=n229
XU314 ADDFX2 $PINS A=n296 B=n294 CI=n289 S=n287 CO=n286
XU383 NAND2BXL $PINS AN=n210 B=n211 Y=n493
XU384 ADDFX2 $PINS A=a[8] B=a[6] CI=a[9] S=n347 CO=n346
XU385 XOR2X2 $PINS A=n201 B=n491 Y=product[14]
XU386 OAI21X2 $PINS A0=n484 A1=n213 B0=n214 Y=n212
XU387 INVX1 $PINS A=n177 Y=n175
XU388 NAND2X1 $PINS A=n92 B=a[13] Y=n85
XU390 OAI21XL $PINS A0=n136 A1=n35 B0=n36 Y=n34
XU391 OR2X2 $PINS A=n128 B=n124 Y=n468
XU392 NAND2X1 $PINS A=n468 B=n125 Y=n119
XU394 AOI21XL $PINS A0=n119 A1=n479 B0=n112 Y=n106
XU395 NAND2X1 $PINS A=n469 B=FE_OFN6086_n205 Y=n471
XU396 NAND2X2 $PINS A=n471 B=n147 Y=n145
XU397 INVX1 $PINS A=n146 Y=n469
XU399 XNOR2X4 $PINS A=n145 B=n490 Y=product[20]
XU400 ADDFX2 $PINS A=a[11] B=a[3] CI=a[13] S=n321 CO=n320
XU401 ADDFX2 $PINS A=a[9] B=FE_RN_2 CI=a[11] S=n333 CO=n332
XU402 ADDFHX1 $PINS A=a[11] B=n350 CI=n347 S=n345 CO=n344
XU403 XNOR2X1 $PINS A=n225 B=n18 Y=product[9]
XU404 ADDFX2 $PINS A=a[13] B=a[10] CI=a[11] S=n337 CO=n336
XU406 ADDFX2 $PINS A=a[3] B=FE_RN_2 CI=_register_5_4 S=n367 CO=n366
XU407 ADDFX2 $PINS A=a[12] B=_register_5_4 CI=a[14] S=n315 CO=n314
XU408 ADDFX2 $PINS A=a[17] B=a[15] CI=n320 S=n313 CO=n312
XU409 ADDFX2 $PINS A=a[13] B=a[5] CI=a[15] S=n309 CO=n308
XU410 ADDFX2 $PINS A=n321 B=n324 CI=n319 S=n317 CO=n316
XU411 ADDFX2 $PINS A=a[19] B=a[18] CI=n291 S=n289 CO=n288
XU412 ADDFX2 $PINS A=a[19] B=a[9] CI=a[17] S=n285 CO=n284
XU413 ADDFX2 $PINS A=n336 B=n333 CI=n331 S=n329 CO=n328
XU414 ADDFX2 $PINS A=a[6] B=n370 CI=n367 S=n365 CO=n364
XU415 XOR2X1 $PINS A=n238 B=n21 Y=product[6]
XU416 NAND2X1 $PINS A=n311 B=n316 Y=n171
XU417 ADDFX2 $PINS A=n302 B=n295 CI=n300 S=n293 CO=n292
XU418 ADDHXL $PINS A=a[19] B=a[11] S=n279 CO=n278
XU419 NAND2X1 $PINS A=n179 B=n197 Y=n177
XU420 XOR2X2 $PINS A=n488 B=n14 Y=product[13]
XU421 XNOR2X1 $PINS A=n64 B=p4 Y=product[29]
XU423 XNOR2X1 $PINS A=n126 B=n4 Y=product[23]
XU424 XOR2X1 $PINS A=n243 B=n492 Y=product[5]
XU426 NAND2X1 $PINS A=n272 B=n233 Y=n20
XU427 INVX1 $PINS A=n232 Y=n272
XU428 NOR2X1 $PINS A=n213 B=n210 Y=n208
XU429 NAND2X1 $PINS A=n341 B=n344 Y=n211
XU430 NOR2BX1 $PINS AN=n182 B=n181 Y=n489
XU431 NAND2X1 $PINS A=n345 B=n348 Y=n214
XU432 AOI21X2 $PINS A0=n243 A1=n475 B0=n240 Y=n238
XU433 INVX1 $PINS A=n242 Y=n240
XU434 NOR2BX1 $PINS AN=n200 B=n199 Y=n491
XU435 NAND2BX1 $PINS AN=n236 B=n237 Y=n21
XU436 NAND2BX1 $PINS AN=n103 B=n82 Y=n81
XU437 NAND2BX1 $PINS AN=n213 B=n214 Y=n16
XU438 NAND2BXL $PINS AN=n131 B=n132 Y=n5
XU439 OAI21XL $PINS A0=n128 A1=n74 B0=n75 Y=n73
XU440 NAND2BX1 $PINS AN=n163 B=n164 Y=n9
XU441 OR2X2 $PINS A=n375 B=FE_OFN100_N1281 Y=n247
XU442 NOR2X1 $PINS A=n335 B=n340 Y=n202
XU443 NAND2X1 $PINS A=n353 B=n356 Y=n224
XU444 NAND2XL $PINS A=n280 B=n279 Y=n114
XU445 AOI21X1 $PINS A0=n247 A1=n251 B0=n248 Y=n246
XU446 INVX1 $PINS A=n250 Y=n248
XU447 NAND2BXL $PINS AN=n229 B=n230 Y=n19
XU448 OAI2BB1X1 $PINS A0N=FE_DBTN167_n152 A1N=n162 B0=n153 Y=n149
XU450 NAND2BX1 $PINS AN=n202 B=n203 Y=n14
XU451 NAND2BX1 $PINS AN=n218 B=n219 Y=n17
XU452 AOI21X1 $PINS A0=n123 A1=n96 B0=n97 Y=n95
XU453 INVX1 $PINS A=n125 Y=n123
XU454 NAND2X1 $PINS A=n247 B=n250 Y=n24
XU455 OR2X2 $PINS A=n486 B=n487 Y=n231
XU456 INVXL $PINS A=n233 Y=n487
XU457 NAND2X1 $PINS A=n221 B=n224 Y=n18
XU458 OAI222XL $PINS A0=n473 A1=n114 B0=n125 B1=n50 C0=n81 C1=n54 Y=n49
XU459 INVX1 $PINS A=n52 Y=n473
XU461 INVX1 $PINS A=n161 Y=n159
XU462 NAND2BXL $PINS AN=n244 B=n245 Y=n23
XU463 NOR2X2 $PINS A=n311 B=n316 Y=n170
XU464 NAND2XL $PINS A=n62 B=a[17] Y=n54
XU465 NAND2X1 $PINS A=n19 B=n231 Y=n476
XU466 OAI2BB1X1 $PINS A0N=n118 A1N=FE_OFN337_n136 B0=n117 Y=n115
XU468 NAND2X1 $PINS A=n122 B=n76 Y=n74
XU469 XNOR2X2 $PINS A=n190 B=n12 Y=product[15]
XU470 NAND2X1 $PINS A=n175 B=n168 Y=n166
XU471 INVX1 $PINS A=n170 Y=n168
XU472 AOI21X1 $PINS A0=n176 A1=n161 B0=n162 Y=n156
XU473 INVX1 $PINS A=n178 Y=n176
XU474 OR2X2 $PINS A=n231 B=n19 Y=n477
XU475 XNOR2X1 $PINS A=n41 B=p6 Y=product[31]
XU476 NOR2X1 $PINS A=n373 B=n481 Y=n244
XU477 NOR2X1 $PINS A=n109 B=n80 Y=n76
XU478 NOR2X2 $PINS A=n317 B=n322 Y=n181
XU479 AND2X2 $PINS A=a[16] B=a[15] Y=n62
XU480 NAND2BX1 $PINS AN=n143 B=n144 Y=n490
XU481 XNOR2X1 $PINS A=n84 B=p2 Y=product[27]
XU482 OAI21X1 $PINS A0=n488 A1=n177 B0=n178 Y=n172
XU483 OAI21XL $PINS A0=n199 A1=n203 B0=n200 Y=n198
XU484 XOR2X1 $PINS A=n234 B=n20 Y=product[7]
XU485 ADDFHX2 $PINS A=a[8] B=n362 CI=n359 S=n357 CO=n356
XU486 ADDHXL $PINS A=a[16] B=FE_OFN50_register_5__8 S=n291 CO=n290
XU487 AND2X1 $PINS A=n475 B=n242 Y=n492
XU488 ADDFX2 $PINS A=n290 B=n285 CI=n288 S=n283 CO=n282
XU489 NOR2X1 $PINS A=n283 B=n286 Y=n131
XU490 NAND2XL $PINS A=n283 B=n286 Y=n132
XU491 NOR2X2 $PINS A=n299 B=n304 Y=n152
XU492 NOR2X1 $PINS A=n159 B=n152 Y=n148
XU493 AOI21X4 $PINS A0=n137 A1=FE_OFN6086_n205 B0=n138 Y=n136
XU494 XOR2X1 $PINS A=n136 B=n6 Y=product[21]
XU495 ADDFX2 $PINS A=a[10] B=a[2] CI=a[12] S=n327 CO=n326
XU496 ADDFHX1 $PINS A=a[12] B=n346 CI=n343 S=n341 CO=n340
XU497 NAND2X1 $PINS A=n373 B=n481 Y=n245
XU498 NOR2X1 $PINS A=n234 B=n232 Y=n486
XU499 NOR2X1 $PINS A=n278 B=a[12] Y=n102
XU500 ADDFHX1 $PINS A=a[9] B=a[7] CI=a[10] S=n343 CO=n342
XU501 ADDFHX1 $PINS A=a[9] B=n358 CI=n355 S=n353 CO=n352
XU502 NAND2X1 $PINS A=n148 B=n175 Y=n146
XU503 ADDHXL $PINS A=a[15] B=a[7] S=n297 CO=n296
XU505 NOR2X1 $PINS A=n323 B=n328 Y=n188
XU507 NAND2XL $PINS A=n72 B=n62 Y=n58
XU508 ADDFX2 $PINS A=n327 B=n330 CI=n325 S=n323 CO=n322
XU509 ADDFX2 $PINS A=a[18] B=a[16] CI=n314 S=n307 CO=n306
XU510 NOR2X1 $PINS A=n188 B=n181 Y=n179
XU511 NOR2X2 $PINS A=n170 B=n163 Y=n161
XU512 INVX1 $PINS A=n189 Y=n187
XU513 NAND2X1 $PINS A=n197 B=n186 Y=n184
XU514 NAND2X1 $PINS A=n317 B=n322 Y=n182
XU516 NOR2X1 $PINS A=n329 B=n334 Y=n199
XU517 INVX1 $PINS A=n235 Y=n234
XU520 OAI21XL $PINS A0=n143 A1=n153 B0=n144 Y=n142
XU521 NAND2X1 $PINS A=n161 B=n141 Y=n139
XU522 NOR2X1 $PINS A=n134 B=n131 Y=n129
XU523 NOR2X1 $PINS A=n305 B=n310 Y=n163
XU525 NOR2X1 $PINS A=n298 B=n293 Y=n143
XU526 AOI21X1 $PINS A0=n208 A1=n217 B0=n209 Y=n207
XU528 NOR2X1 $PINS A=n282 B=n281 Y=n124
XU529 INVX1 $PINS A=n129 Y=n127
XU530 NAND2X1 $PINS A=n369 B=n372 Y=n242
XU531 ADDFX2 $PINS A=_register_5_4 B=FE_RN_2 CI=a[2] S=n373 CO=n372
XU532 OAI21XL $PINS A0=n94 A1=n128 B0=n95 Y=n93
XU533 NOR2X1 $PINS A=n127 B=n94 Y=n92
XU534 XNOR2X1 $PINS A=n69 B=p3 Y=product[28]
XU535 OAI21XL $PINS A0=n136 A1=n70 B0=n71 Y=n69
XU536 INVX1 $PINS A=n72 Y=n70
XU537 INVX1 $PINS A=n73 Y=n71
XU538 XNOR2X2 $PINS A=n133 B=n5 Y=product[22]
XU539 OR2X2 $PINS A=n369 B=n372 Y=n475
XU540 AOI21X1 $PINS A0=n141 A1=n162 B0=n142 Y=n140
XU541 OAI21X1 $PINS A0=n171 A1=n163 B0=n164 Y=n162
XU542 NAND2X1 $PINS A=n375 B=FE_OFN100_N1281 Y=n250
XU544 XNOR2X1 $PINS A=n57 B=p5 Y=product[30]
XU545 NOR2X1 $PINS A=n152 B=n143 Y=n141
XU546 NAND2X1 $PINS A=n365 B=n368 Y=n237
XU547 NAND2X2 $PINS A=n476 B=n477 Y=product[8]
XU548 INVX1 $PINS A=n253 Y=n251
XU549 AOI21X2 $PINS A0=n179 A1=FE_OFN5734_n198 B0=n180 Y=n178
XU550 OAI21XL $PINS A0=n181 A1=n189 B0=n182 Y=n180
XU551 ADDFX2 $PINS A=a[5] B=a[3] CI=n371 S=n369 CO=n368
XU552 XOR2X1 $PINS A=a[3] B=FE_RN_2 Y=n375
XU553 NOR2X1 $PINS A=n365 B=n368 Y=n236
XU554 CMPR22X1 $PINS A=a[2] B=FE_OFN100_N1281 S=n371 CO=n370
XU555 OAI21X1 $PINS A0=n244 A1=n246 B0=n245 Y=n243
XU556 OAI21XL $PINS A0=n114 A1=n80 B0=n81 Y=n77
XU557 NAND2X1 $PINS A=n93 B=a[13] Y=n86
XU558 OAI21XL $PINS A0=n229 A1=n233 B0=n230 Y=n228
XU559 NOR2X1 $PINS A=n229 B=n232 Y=n227
XU560 NAND2XL $PINS A=n73 B=a[15] Y=n66
XU561 NAND2XL $PINS A=n72 B=a[15] Y=n65
XU562 ADDHXL $PINS A=a[8] B=FE_OFN100_N1281 S=n339 CO=n338
XU563 ADDFX2 $PINS A=_register_5_4 B=a[2] CI=a[5] S=n363 CO=n362
XU564 ADDFX2 $PINS A=a[18] B=a[17] CI=n297 S=n295 CO=n294
XU565 ADDFX2 $PINS A=n309 B=n312 CI=n307 S=n305 CO=n304
XU566 NAND2X1 $PINS A=n329 B=n334 Y=n200
XU567 NAND2X1 $PINS A=n335 B=n340 Y=n203
XU568 OAI21XL $PINS A0=n131 A1=n135 B0=n132 Y=n130
XU569 OAI21X1 $PINS A0=n488 A1=n184 B0=n185 Y=n183
XU570 INVX1 $PINS A=n197 Y=n191
XU571 OAI21XL $PINS A0=n136 A1=n105 B0=n106 Y=n104
XU572 INVX1 $PINS A=n93 Y=n91
XU573 INVX1 $PINS A=n92 Y=n90
XU574 OAI21XL $PINS A0=n136 A1=n58 B0=n59 Y=n57
XU576 ADDFHX1 $PINS A=a[10] B=n354 CI=n351 S=n349 CO=n348
XU577 ADDFX2 $PINS A=a[6] B=_register_5_4 CI=a[7] S=n355 CO=n354
XU578 OR2X2 $PINS A=n47 B=n31 Y=n478
XU579 OR2X2 $PINS A=n280 B=n279 Y=n479
XU580 INVX1 $PINS A=n124 Y=n122
XU581 AOI21X1 $PINS A0=n48 A1=FE_OFN5939_n130 B0=n49 Y=n47
XU582 OR2X2 $PINS A=n46 B=n31 Y=n480
XU583 AND2X2 $PINS A=a[3] B=FE_RN_2 Y=n481
XU584 AND2X2 $PINS A=n494 B=n253 Y=product[2]
XU585 NAND2X1 $PINS A=n129 B=n48 Y=n46
XU586 INVX1 $PINS A=n188 Y=n186
XU587 NOR2X1 $PINS A=n199 B=n202 Y=n197
XU588 NAND2XL $PINS A=FE_DBTN167_n152 B=n153 Y=n8
XU589 ADDFX2 $PINS A=a[5] B=a[3] CI=a[6] S=n359 CO=n358
XU590 OAI21X1 $PINS A0=n178 A1=n139 B0=n140 Y=n138
XU591 XNOR2X2 $PINS A=n172 B=n10 Y=product[17]
XU592 OAI21X2 $PINS A0=n488 A1=n191 B0=n192 Y=n190
XU594 AOI21X4 $PINS A0=n225 A1=n216 B0=n217 Y=n484
XU595 NOR2X1 $PINS A=n177 B=n139 Y=n137
XU596 INVX4 $PINS A=n226 Y=n225
XU597 NOR2X1 $PINS A=n109 B=n102 Y=n96
XU598 NAND2X1 $PINS A=n323 B=n328 Y=n189
XU600 XOR2X2 $PINS A=n484 B=n16 Y=product[11]
XU602 NAND2X1 $PINS A=n357 B=n360 Y=n230
XU603 OAI21XL $PINS A0=n136 A1=n127 B0=n128 Y=n126
XU605 NAND2X1 $PINS A=n479 B=n52 Y=n50
XU606 NOR2X1 $PINS A=n80 B=n54 Y=n52
XU607 XNOR2X2 $PINS A=n165 B=n9 Y=product[18]
XU608 OAI21X2 $PINS A0=n166 A1=n488 B0=n167 Y=n165
XU609 NAND2X1 $PINS A=n292 B=n287 Y=n135
XU610 XNOR2X4 $PINS A=n154 B=n8 Y=product[19]
XU612 ADDFX2 $PINS A=n339 B=n342 CI=n337 S=n335 CO=n334
XU613 NOR2X1 $PINS A=n127 B=n74 Y=n72
XU614 ADDFX2 $PINS A=n303 B=n306 CI=n301 S=n299 CO=n298
XU615 AOI21X1 $PINS A0=n225 A1=n221 B0=n222 Y=n220
XU616 NAND2X1 $PINS A=n349 B=n352 Y=n219
XU617 AOI21X1 $PINS A0=n148 A1=n176 B0=n149 Y=n147
XU618 OAI21X1 $PINS A0=n136 A1=n134 B0=n135 Y=n133
XU619 AOI21X2 $PINS A0=n235 A1=n227 B0=n228 Y=n226
XU620 XOR2X2 $PINS A=n220 B=n17 Y=product[10]
XU621 NAND2X1 $PINS A=n361 B=n364 Y=n233
XU622 OAI21X2 $PINS A0=n238 A1=n236 B0=n237 Y=n235
XU623 NOR2X1 $PINS A=n361 B=n364 Y=n232
XU624 ADDFHX2 $PINS A=a[7] B=n366 CI=n363 S=n361 CO=n360
XU626 NOR2X2 $PINS A=n349 B=n352 Y=n218
XU627 NAND2X1 $PINS A=n73 B=n62 Y=n59
XU628 OAI21XL $PINS A0=n210 A1=n214 B0=n211 Y=n209
XU629 XNOR2X2 $PINS A=n212 B=n493 Y=product[12]
XU630 OAI21XL $PINS A0=n136 A1=n65 B0=n66 Y=n64
XU631 INVXL $PINS A=n119 Y=n117
XU632 XOR2X2 $PINS A=n183 B=n489 Y=product[16]
XU633 INVX1 $PINS A=n479 Y=n109
XU635 NAND2BXL $PINS AN=n134 B=n135 Y=n6
XU636 AOI21XL $PINS A0=n76 A1=n123 B0=n77 Y=n75
XU637 NAND2BXL $PINS AN=n124 B=n125 Y=n4
XU638 NAND2BX1 $PINS AN=n102 B=n103 Y=n2
XU639 NOR2X1 $PINS A=p1 B=p2 Y=n82
XU640 INVX1 $PINS A=n102 Y=n100
XU641 NAND2XL $PINS A=n44 B=a[18] Y=n35
XU642 NAND2XL $PINS A=n45 B=a[18] Y=n36
XU643 ADDFX2 $PINS A=a[7] B=a[5] CI=a[8] S=n351 CO=n350
XU644 OR2XL $PINS A=a[2] B=FE_OFN36_N1281 Y=n494
XU645 ADDFX2 $PINS A=a[15] B=a[13] CI=n332 S=n325 CO=n324
XU646 ADDFX2 $PINS A=a[14] B=a[12] CI=n338 S=n331 CO=n330
XU648 NAND2X1 $PINS A=n118 B=n479 Y=n105
XU649 NOR2X1 $PINS A=n127 B=n124 Y=n118
XU651 INVX1 $PINS A=n46 Y=n44
XU652 NAND2X1 $PINS A=n96 B=n122 Y=n94
XU653 AOI21X1 $PINS A0=n198 A1=n186 B0=n187 Y=n185
XU655 NAND2X1 $PINS A=n186 B=n189 Y=n12
XU656 NAND2X1 $PINS A=n168 B=n171 Y=n10
XU657 INVX1 $PINS A=n47 Y=n45
XU658 OAI21XL $PINS A0=n136 A1=n480 B0=n478 Y=n26
XU659 OAI21XL $PINS A0=n114 A1=n102 B0=n103 Y=n97
XU660 NAND2X1 $PINS A=n299 B=n304 Y=n153
XU661 NAND2X1 $PINS A=n100 B=n82 Y=n80
XU662 NAND2X1 $PINS A=n305 B=n310 Y=n164
XU663 NAND2X1 $PINS A=n298 B=n293 Y=n144
XU664 NAND2X1 $PINS A=n479 B=n114 Y=n3
XU665 XNOR2X1 $PINS A=n24 B=n251 Y=product[3]
XU666 XOR2XL $PINS A=n23 B=n246 Y=product[4]
XU667 INVX1 $PINS A=n114 Y=n112
XU668 INVXL $PINS A=n224 Y=n222
XU669 NOR2X1 $PINS A=n50 B=n124 Y=n48
XU670 NAND2X1 $PINS A=n282 B=n281 Y=n125
XU671 OAI21XL $PINS A0=n136 A1=n46 B0=n47 Y=n41
XU672 XNOR2X1 $PINS A=n34 B=p7 Y=product[32]
XU673 ADDFX2 $PINS A=n315 B=n318 CI=n313 S=n311 CO=n310
XU675 NAND2X1 $PINS A=a[18] B=a[19] Y=n31
XU676 NAND2XL $PINS A=a[2] B=FE_OFN36_N1281 Y=n253
XU677 ADDFX2 $PINS A=a[18] B=a[10] CI=n284 S=n281 CO=n280
XU678 ADDFX2 $PINS A=a[14] B=a[6] CI=a[16] S=n303 CO=n302
XU679 ADDFX2 $PINS A=a[19] B=a[17] CI=n308 S=n301 CO=n300
XU680 ADDFX2 $PINS A=a[16] B=a[14] CI=n326 S=n319 CO=n318
XU681 NAND2XL $PINS A=n278 B=a[12] Y=n103
XU460 OAI2BB1X2 $PINS A0N=n225 A1N=n495 B0=n207 Y=n205
XU524 AND2X2 $PINS A=n216 B=n208 Y=n495
XU593 OR3XL $PINS A=n159 B=n488 C=n177 Y=n497
XU625 NAND2X2 $PINS A=n497 B=n156 Y=n154
XU686 AOI2BB1X2 $PINS A0N=n178 A1N=n170 B0=n169 Y=n167
.ENDS

.SUBCKT CONV_DW_mult_uns_26_0 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[15] b[14]
+ b[13] b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0]
+ product[35] product[34] product[33] product[32] product[31] product[30]
+ product[29] product[28] product[27] product[26] product[25] product[24]
+ product[23] product[22] product[21] product[20] product[19] product[18]
+ product[17] product[16] product[15] product[14] product[13] product[12]
+ product[11] product[10] product[9] product[8] product[7] product[6]
+ product[5] product[4] product[3] product[2] product[1] product[0] n4996
+ _register_0_17 p1 p2 p3 p4 p5 p6 p7 p8 p9 p10 p11 p12 p13
+ FE_OFN339_register_0__3 FE_OFN388_register_0__11 _register_0_3 p14 p15 p16
XFE_OCPC2320_register_0__13 BUFX3 $PINS A=a[13] Y=FE_OCPN6224_register_0__13
XFE_OFC1759_register_0__17 INVX1 $PINS A=_register_0_17 Y=FE_RN_2
XFE_OFC1717_n234 INVX1 $PINS A=n233 Y=FE_OFN5841_n234
XFE_OFC1716_n234 INVX1 $PINS A=n234 Y=n233
XFE_OFC1658_register_0__10 INVXL $PINS A=a[10] Y=n458
XFE_OFC1639_n6772 INVX1 $PINS A=FE_DBTN184_n6772 Y=FE_OFN5803_n6772
XFE_OFC1638_n6772 INVX1 $PINS A=a[15] Y=FE_DBTN184_n6772
XFE_OFC1515_register_0__19 INVX1 $PINS A=a[19] Y=FE_RN_1
XFE_OFC581_n254 INVX1 $PINS A=n254 Y=n253
XFE_OFC159_n166 INVX4 $PINS A=n166 Y=FE_DBTN166_n166
XU49 XNOR2X1 $PINS A=n81 B=n6 Y=product[30]
XU121 NOR2X1 $PINS A=n131 B=n124 Y=n122
XU144 AOI21X1 $PINS A0=n159 A1=n140 B0=n141 Y=n139
XU173 NOR2X1 $PINS A=n366 B=n373 Y=n160
XU183 OAI21X4 $PINS A0=n167 A1=n187 B0=n168 Y=n166
XU190 NOR2X2 $PINS A=n382 B=n389 Y=n171
XU196 NOR2X1 $PINS A=n390 B=n397 Y=n174
XU206 XNOR2X2 $PINS A=n186 B=n20 Y=product[16]
XU216 AOI21X4 $PINS A0=n188 A1=n207 B0=n189 Y=n187
XU245 OAI21X2 $PINS A0=n225 A1=n208 B0=n209 Y=n207
XU272 AOI21X1 $PINS A0=FE_OFN5841_n234 A1=n226 B0=n227 Y=n225
XU461 NAND2BX1 $PINS AN=n174 B=n175 Y=n18
XU462 NAND2X1 $PINS A=n276 B=n180 Y=n19
XU463 OAI21XL $PINS A0=FE_DBTN166_n166 A1=n138 B0=n139 Y=n133
XU464 NOR2X1 $PINS A=n179 B=n184 Y=n177
XU465 INVX1 $PINS A=n138 Y=n136
XU466 NOR2X1 $PINS A=n350 B=n357 Y=n142
XU467 NAND2BX1 $PINS AN=n231 B=n232 Y=n28
XU468 NAND2X1 $PINS A=n446 B=n447 Y=n232
XU469 NAND2X1 $PINS A=n166 B=n566 Y=n567
XU470 NAND2X1 $PINS A=n567 B=n128 Y=n126
XU472 INVX1 $PINS A=n127 Y=n566
XU473 NAND2X1 $PINS A=n166 B=n569 Y=n570
XU474 NAND2X1 $PINS A=n570 B=n117 Y=n115
XU476 INVX1 $PINS A=n116 Y=n569
XU477 XOR2X1 $PINS A=n115 B=n600 Y=product[26]
XU478 XOR2X1 $PINS A=a[9] B=a[1] Y=n571
XU479 XOR2X1 $PINS A=n584 B=n571 Y=n424
XU480 NAND2XL $PINS A=a[9] B=n584 Y=n572
XU481 NAND2XL $PINS A=a[1] B=n584 Y=n573
XU482 NAND2XL $PINS A=a[1] B=a[9] Y=n574
XU483 NAND3X1 $PINS A=n574 B=n572 C=n573 Y=n423
XU486 AND2X2 $PINS A=p1 B=a[6] Y=n584
XU487 AND2X1 $PINS A=n137 B=n122 Y=n575
XU488 NOR2X1 $PINS A=n575 B=n123 Y=n117
XU489 INVX1 $PINS A=n139 Y=n137
XU490 OAI21XL $PINS A0=n124 A1=n132 B0=n125 Y=n123
XU491 OAI21XL $PINS A0=n217 A1=n223 B0=n218 Y=n216
XU492 NAND2X1 $PINS A=n438 B=n441 Y=n218
XU493 NOR2X1 $PINS A=n438 B=n441 Y=n217
XU494 AOI21X2 $PINS A0=n588 A1=n178 B0=n170 Y=n168
XU495 OAI21XL $PINS A0=n171 A1=n175 B0=n172 Y=n170
XU496 NAND2X1 $PINS A=n398 B=n405 Y=n180
XU497 XNOR2X1 $PINS A=n253 B=a[2] Y=product[3]
XU499 INVX1 $PINS A=a[2] Y=n466
XU500 NAND2X1 $PINS A=n382 B=n389 Y=n172
XU501 ADDFHX1 $PINS A=n393 B=n391 CI=n384 S=n382 CO=n381
XU502 NOR2X1 $PINS A=n444 B=n445 Y=n228
XU503 ADDFX2 $PINS A=a[2] B=a[4] CI=p5 S=n444 CO=n443
XU504 NOR2X1 $PINS A=n374 B=n381 Y=n163
XU505 ADDFX2 $PINS A=n385 B=n383 CI=n376 S=n374 CO=n373
XU506 XOR2X1 $PINS A=n181 B=n19 Y=product[17]
XU507 NOR2BX1 $PINS AN=n185 B=n593 Y=n181
XU509 NOR2X1 $PINS A=n163 B=n160 Y=n158
XU510 XNOR2X1 $PINS A=n57 B=n4 Y=product[32]
XU511 OAI21XL $PINS A0=n97 A1=n58 B0=n59 Y=n57
XU512 OAI21XL $PINS A0=n104 A1=n114 B0=n105 Y=n103
XU514 ADDFX2 $PINS A=_register_0_3 B=a[7] CI=p9 S=n426 CO=n425
XU516 ADDFX2 $PINS A=_register_0_3 B=p7 CI=FE_DBTN184_n6772 S=n412 CO=n411
XU517 INVX1 $PINS A=a[4] Y=n464
XU518 ADDFX2 $PINS A=a[10] B=a[6] CI=a[14] S=n370 CO=n369
XU519 ADDFX2 $PINS A=a[1] B=_register_0_3 CI=p4 S=n446 CO=n445
XU520 ADDFX2 $PINS A=a[14] B=p7 CI=n324 S=n322 CO=n321
XU521 ADDFX2 $PINS A=n395 B=n386 CI=n388 S=n384 CO=n383
XU522 ADDFX2 $PINS A=n403 B=n394 CI=n396 S=n392 CO=n391
XU523 ADDFX2 $PINS A=n411 B=n402 CI=n404 S=n400 CO=n399
XU524 ADDFX2 $PINS A=a[7] B=p7 CI=a[15] S=n362 CO=n361
XU525 XOR2X1 $PINS A=n219 B=n25 Y=product[11]
XU526 NAND2X1 $PINS A=n444 B=n445 Y=n229
XU527 NAND2X1 $PINS A=n442 B=n443 Y=n223
XU528 INVX1 $PINS A=n225 Y=n224
XU529 ADDFX2 $PINS A=n354 B=n359 CI=n352 S=n350 CO=n349
XU530 NAND2X1 $PINS A=n586 B=n587 Y=product[15]
XU531 NAND2X1 $PINS A=n366 B=n373 Y=n161
XU532 NAND2X1 $PINS A=n374 B=n381 Y=n164
XU533 NOR2X1 $PINS A=n334 B=n341 Y=n124
XU534 XOR2X1 $PINS A=n206 B=n23 Y=product[13]
XU536 OAI21XL $PINS A0=FE_DBTN166_n166 A1=n107 B0=n108 Y=n106
XU539 NAND2BX1 $PINS AN=n163 B=n164 Y=n16
XU540 NOR2BX1 $PINS AN=n125 B=n124 Y=n601
XU541 NAND2BX1 $PINS AN=n142 B=n143 Y=n13
XU542 NAND2BX1 $PINS AN=n228 B=n229 Y=n27
XU543 AND2X2 $PINS A=n122 B=n112 Y=n109
XU544 OAI2BB1X1 $PINS A0N=n166 A1N=n576 B0=n164 Y=n162
XU545 INVX1 $PINS A=n163 Y=n576
XU546 NAND2XL $PINS A=n136 B=n109 Y=n107
XU547 NOR2X1 $PINS A=n448 B=p3 Y=n235
XU548 OAI21XL $PINS A0=n96 A1=n88 B0=n89 Y=n577
XU549 INVX1 $PINS A=n577 Y=n83
XU550 AOI21X1 $PINS A0=n147 A1=n159 B0=n148 Y=n146
XU551 INVXL $PINS A=n150 Y=n148
XU552 XNOR2X1 $PINS A=n106 B=n9 Y=product[27]
XU553 AOI2BB2X1 $PINS A0N=n225 A1N=n222 B0=n442 B1=n443 Y=n219
XU554 NAND2BX1 $PINS AN=n243 B=n244 Y=n31
XU555 OAI21XL $PINS A0=n79 A1=n89 B0=n80 Y=n578
XU556 INVX1 $PINS A=n578 Y=n76
XU557 NOR2X2 $PINS A=n174 B=n171 Y=n588
XU558 NAND2BX1 $PINS AN=n240 B=n241 Y=n30
XU559 OR2X2 $PINS A=n149 B=n156 Y=n145
XU560 INVXL $PINS A=n158 Y=n156
XU561 OAI2BB1X1 $PINS A0N=n123 A1N=n112 B0=n114 Y=n110
XU562 INVX1 $PINS A=n113 Y=n112
XU563 XNOR2X1 $PINS A=n297 B=n294 Y=n4
XU564 NAND2BXL $PINS AN=n160 B=n161 Y=n15
XU565 NAND2BX1 $PINS AN=n217 B=n218 Y=n25
XU566 OR2X2 $PINS A=n192 B=n21 Y=n587
XU567 NAND2X1 $PINS A=n342 B=n349 Y=n132
XU568 NAND2BXL $PINS AN=n204 B=n205 Y=n23
XU569 OAI2BB2X1 $PINS A0N=n293 A1N=n292 B0=n52 B1=n44 Y=n43
XU570 OAI2BB2X1 $PINS A0N=n448 A1N=p3 B0=n237 B1=n235 Y=n234
XU571 OAI21XL $PINS A0=n197 A1=n205 B0=n198 Y=n579
XU572 INVX1 $PINS A=n579 Y=n194
XU573 NAND2XL $PINS A=n147 B=n150 Y=n14
XU574 XOR3X2 $PINS A=n46 B=n293 C=n292 Y=product[33]
XU575 NAND2BX1 $PINS AN=n190 B=n191 Y=n21
XU576 NOR2X1 $PINS A=n320 B=n325 Y=n104
XU577 NAND2BX1 $PINS AN=n159 B=n592 Y=n151
XU578 XOR3X2 $PINS A=n39 B=n291 C=FE_RN_1 Y=product[34]
XU579 OAI21XL $PINS A0=n206 A1=n193 B0=n194 Y=n192
XU580 CLKINVX3 $PINS A=n207 Y=n206
XU581 NOR2BX1 $PINS AN=n172 B=n171 Y=n596
XU582 XNOR2X1 $PINS A=n250 B=a[3] Y=product[4]
XU583 AOI22X1 $PINS A0=n297 A1=n294 B0=n63 B1=n589 Y=n52
XU584 OAI21X1 $PINS A0=n139 A1=n100 B0=n101 Y=n99
XU585 OR2X2 $PINS A=n197 B=n204 Y=n193
XU586 XNOR3X2 $PINS A=n237 B=n448 C=p3 Y=product[7]
XU587 OR2X2 $PINS A=n88 B=n79 Y=n75
XU588 AOI21X1 $PINS A0=n102 A1=n123 B0=n103 Y=n101
XU590 XNOR2X1 $PINS A=n97 B=n597 Y=product[28]
XU592 XOR2X1 $PINS A=n245 B=n31 Y=product[5]
XU593 OAI21X1 $PINS A0=n179 A1=n185 B0=n180 Y=n178
XU594 ADDHXL $PINS A=p1 B=a[2] S=n448 CO=n447
XU596 NAND2X1 $PINS A=n406 B=n413 Y=n185
XU597 NOR2X2 $PINS A=n398 B=n405 Y=n179
XU598 OAI21X1 $PINS A0=n160 A1=n164 B0=n161 Y=n159
XU599 NAND2X1 $PINS A=n158 B=n140 Y=n138
XU600 ADDFX2 $PINS A=a[12] B=a[4] CI=a[8] S=n386 CO=n385
XU601 XOR2X1 $PINS A=n424 B=n426 Y=n580
XU602 XOR2X1 $PINS A=n429 B=n580 Y=n422
XU603 NAND2XL $PINS A=n424 B=n429 Y=n581
XU604 NAND2X1 $PINS A=n426 B=n429 Y=n582
XU605 NAND2XL $PINS A=n426 B=n424 Y=n583
XU606 NAND3X1 $PINS A=n583 B=n581 C=n582 Y=n421
XU607 XNOR2XL $PINS A=a[16] B=a[12] Y=n324
XU608 CMPR32X1 $PINS A=a[8] B=a[12] C=a[16] S=n354 CO=n353
XU609 ADDFXL $PINS A=a[19] B=a[14] CI=_register_0_17 S=n304 CO=n303
XU610 XNOR2X1 $PINS A=n242 B=n30 Y=product[6]
XU611 OAI21XL $PINS A0=n245 A1=n243 B0=n244 Y=n242
XU612 ADDHXL $PINS A=a[2] B=a[10] S=n420 CO=n419
XU613 NOR2X1 $PINS A=n149 B=n142 Y=n140
XU614 NOR2X1 $PINS A=n365 B=n358 Y=n149
XU615 NOR2X1 $PINS A=n113 B=n104 Y=n102
XU617 ADDFX2 $PINS A=a[8] B=n420 CI=n425 S=n416 CO=n415
XU618 ADDFX2 $PINS A=n419 B=n417 CI=n410 S=n408 CO=n407
XU620 ADDFX2 $PINS A=p7 B=_register_0_3 CI=a[7] S=n394 CO=n393
XU621 ADDFX2 $PINS A=FE_OFN5803_n6772 B=FE_OCPN6224_register_0__13 CI=FE_RN_2
+ S=n316 CO=n315
XU622 ADDFX2 $PINS A=n401 B=n399 CI=n392 S=n390 CO=n389
XU623 ADDFX2 $PINS A=n418 B=n423 CI=n416 S=n414 CO=n413
XU624 ADDFX2 $PINS A=n372 B=n377 CI=n370 S=n368 CO=n367
XU625 NAND2X1 $PINS A=n434 B=n437 Y=n213
XU626 NAND2X1 $PINS A=n414 B=n421 Y=n191
XU627 ADDFX2 $PINS A=n379 B=n368 CI=n375 S=n366 CO=n365
XU628 ADDFX2 $PINS A=n362 B=n360 CI=n367 S=n358 CO=n357
XU629 XNOR2X1 $PINS A=n199 B=n22 Y=product[14]
XU630 NAND2BX1 $PINS AN=n197 B=n198 Y=n22
XU631 XNOR2X1 $PINS A=n230 B=n27 Y=product[9]
XU632 XNOR2X1 $PINS A=n90 B=n7 Y=product[29]
XU633 XNOR2X2 $PINS A=n162 B=n15 Y=product[21]
XU634 NAND2X1 $PINS A=n122 B=n102 Y=n100
XU635 INVX1 $PINS A=n74 Y=n72
XU636 OAI21XL $PINS A0=n75 A1=n96 B0=n76 Y=n74
XU637 OR2X2 $PINS A=n434 B=n437 Y=n585
XU638 NAND2X1 $PINS A=n464 B=p1 Y=n244
XU639 NAND2X1 $PINS A=n253 B=n466 Y=n250
XU640 ADDFX2 $PINS A=a[1] B=a[7] CI=FE_OFN388_register_0__11 S=n436 CO=n435
XU642 NOR2X1 $PINS A=n422 B=n427 Y=n197
XU643 INVX1 $PINS A=n246 Y=n245
XU644 INVX1 $PINS A=a[5] Y=n463
XU646 XOR2X1 $PINS A=n176 B=n18 Y=product[18]
XU647 OAI21XL $PINS A0=n176 A1=n174 B0=n175 Y=n173
XU648 XOR2X1 $PINS A=p1 B=a[6] Y=n432
XU649 ADDFX2 $PINS A=a[5] B=n584 CI=n436 S=n434 CO=n433
XU650 NAND2X1 $PINS A=n192 B=n21 Y=n586
XU651 NAND2X1 $PINS A=n350 B=n357 Y=n143
XU652 NAND2X1 $PINS A=n422 B=n427 Y=n198
XU653 OAI21XL $PINS A0=n97 A1=n95 B0=n96 Y=n90
XU654 NOR2X1 $PINS A=n349 B=n342 Y=n131
XU655 OAI21XL $PINS A0=n97 A1=n67 B0=n72 Y=n66
XU657 NOR2X1 $PINS A=n243 B=n240 Y=n238
XU658 NAND2X1 $PINS A=n129 B=n132 Y=n12
XU660 ADDFX2 $PINS A=a[4] B=p1 CI=p10 S=n418 CO=n417
XU661 ADDFX2 $PINS A=a[4] B=a[12] CI=p11 S=n404 CO=n403
XU662 ADDFX2 $PINS A=a[5] B=a[13] CI=FE_RN_2 S=n396 CO=n395
XU663 ADDFX2 $PINS A=a[8] B=a[2] CI=p8 S=n430 CO=n429
XU664 ADDFX2 $PINS A=a[6] B=a[14] CI=p12 S=n388 CO=n387
XU666 ADDFX2 $PINS A=FE_OCPN6224_register_0__13 B=a[5] CI=a[9] S=n378 CO=n377
XU667 ADDFX2 $PINS A=n432 B=n435 CI=n430 S=n428 CO=n427
XU668 NAND2BX1 $PINS AN=a[1] B=p16 Y=n254
XU669 ADDFX2 $PINS A=p12 B=n347 CI=n345 S=n336 CO=n335
XU670 ADDFX2 $PINS A=FE_OCPN6224_register_0__13 B=a[18] CI=FE_OFN5803_n6772
+ S=n330 CO=n329
XU671 INVX1 $PINS A=n184 Y=n182
XU673 NOR2X1 $PINS A=n463 B=a[1] Y=n240
XU674 NOR2X1 $PINS A=n464 B=p1 Y=n243
XU675 ADDFX2 $PINS A=a[7] B=a[15] CI=FE_RN_1 S=n380 CO=n379
XU676 ADDFX2 $PINS A=n387 B=n378 CI=n380 S=n376 CO=n375
XU677 XNOR2X1 $PINS A=a[16] B=a[8] Y=n372
XU678 ADDFX2 $PINS A=n371 B=n364 CI=n369 S=n360 CO=n359
XU679 XNOR2X1 $PINS A=_register_0_17 B=a[9] Y=n364
XU680 ADDFX2 $PINS A=n338 B=n336 CI=n343 S=n334 CO=n333
XU681 NOR2X1 $PINS A=n428 B=n433 Y=n204
XU682 ADDFX2 $PINS A=n330 B=n335 CI=n328 S=n326 CO=n325
XU683 XOR2X1 $PINS A=n214 B=n24 Y=product[12]
XU684 NOR2X1 $PINS A=n75 B=n95 Y=n73
XU685 XNOR2X1 $PINS A=a[1] B=p16 Y=product[2]
XU688 CMPR32X1 $PINS A=a[10] B=a[12] C=a[14] S=n338 CO=n337
XU689 OR2X2 $PINS A=n297 B=n294 Y=n589
XU692 OR2X2 $PINS A=n298 B=n301 Y=n590
XU693 INVX1 $PINS A=n88 Y=n86
XU694 NAND2X1 $PINS A=n428 B=n433 Y=n205
XU695 OR2X2 $PINS A=n40 B=n37 Y=n591
XU697 NOR2X1 $PINS A=n333 B=n326 Y=n113
XU699 NAND2X1 $PINS A=n588 B=n177 Y=n167
XU700 NOR2X1 $PINS A=n193 B=n190 Y=n188
XU701 NAND2X1 $PINS A=n136 B=n129 Y=n127
XU702 NOR2X1 $PINS A=n247 B=n254 Y=n246
XU703 OAI21XL $PINS A0=n240 A1=n244 B0=n241 Y=n239
XU706 OAI21X1 $PINS A0=n194 A1=n190 B0=n191 Y=n189
XU707 ADDFX2 $PINS A=a[9] B=a[1] CI=a[5] S=n410 CO=n409
XU708 NOR2X1 $PINS A=n414 B=n421 Y=n190
XU709 NAND2X1 $PINS A=n215 B=n585 Y=n208
XU710 OAI21XL $PINS A0=n206 A1=n204 B0=n205 Y=n199
XU711 NOR2X1 $PINS A=n446 B=n447 Y=n231
XU712 XOR2X1 $PINS A=n233 B=n28 Y=product[8]
XU713 ADDFX2 $PINS A=a[4] B=n458 CI=n432 S=n438 CO=n437
XU714 NAND2X1 $PINS A=n466 B=a[3] Y=n247
XU715 AOI21X1 $PINS A0=n186 A1=n177 B0=n178 Y=n176
XU716 XOR2X4 $PINS A=FE_DBTN166_n166 B=n16 Y=product[20]
XU717 NAND2BX1 $PINS AN=n184 B=n185 Y=n20
XU718 NOR2X1 $PINS A=n442 B=n443 Y=n222
XU719 XNOR2X2 $PINS A=n133 B=n12 Y=product[24]
XU722 AOI21X1 $PINS A0=n224 A1=n215 B0=n216 Y=n214
XU723 OAI21XL $PINS A0=n233 A1=n231 B0=n232 Y=n230
XU724 XOR2X2 $PINS A=n173 B=n596 Y=product[19]
XU725 OAI21XL $PINS A0=n228 A1=n232 B0=n229 Y=n227
XU726 NOR2X1 $PINS A=n406 B=n413 Y=n184
XU727 ADDFX2 $PINS A=n412 B=n415 CI=n408 S=n406 CO=n405
XU728 NOR2X1 $PINS A=n228 B=n231 Y=n226
XU729 ADDFX2 $PINS A=n409 B=n407 CI=n400 S=n398 CO=n397
XU730 OAI21XL $PINS A0=n97 A1=n82 B0=n83 Y=n81
XU731 AOI21X1 $PINS A0=n238 A1=n246 B0=n239 Y=n237
XU732 OR2X2 $PINS A=FE_DBTN166_n166 B=n156 Y=n592
XU733 XNOR2X4 $PINS A=n151 B=n14 Y=product[22]
XU734 AND2X2 $PINS A=n186 B=n182 Y=n593
XU735 CLKINVX3 $PINS A=n187 Y=n186
XU736 NAND2X1 $PINS A=n390 B=n397 Y=n175
XU737 AOI21X1 $PINS A0=n585 A1=n216 B0=n211 Y=n209
XU738 NOR2X1 $PINS A=n51 B=n44 Y=n42
XU739 INVX1 $PINS A=n222 Y=n220
XU740 NOR2X1 $PINS A=n217 B=n222 Y=n215
XU741 NAND2XL $PINS A=n136 B=n122 Y=n116
XU742 INVX1 $PINS A=n73 Y=n67
XU743 OAI21XL $PINS A0=n142 A1=n150 B0=n143 Y=n141
XU744 NAND2X1 $PINS A=n334 B=n341 Y=n125
XU745 NAND2BXL $PINS AN=n88 B=n89 Y=n7
XU746 NAND2X1 $PINS A=n590 B=n65 Y=n598
XU747 ADDFX2 $PINS A=a[18] B=_register_0_17 CI=a[16] S=n310 CO=n309
XU748 NAND2BXL $PINS AN=n104 B=n105 Y=n9
XU749 AOI21XL $PINS A0=n137 A1=n129 B0=n130 Y=n128
XU750 NAND2XL $PINS A=n93 B=n86 Y=n82
XU751 AND2X2 $PINS A=n93 B=n96 Y=n597
XU752 XNOR2X1 $PINS A=n66 B=n598 Y=product[31]
XU753 NAND2BXL $PINS AN=n79 B=n80 Y=n6
XU754 NAND2XL $PINS A=n333 B=n326 Y=n114
XU755 XOR2X1 $PINS A=n224 B=n599 Y=product[10]
XU756 AND2X2 $PINS A=n220 B=n223 Y=n599
XU757 NAND2X1 $PINS A=n365 B=n358 Y=n150
XU758 ADDFX2 $PINS A=n355 B=n348 CI=n353 S=n344 CO=n343
XU759 OR2XL $PINS A=a[16] B=a[8] Y=n371
XU760 OR2XL $PINS A=a[19] B=p7 Y=n347
XU761 NAND2X1 $PINS A=n73 B=n590 Y=n58
XU763 NAND2XL $PINS A=n73 B=n49 Y=n47
XU764 INVX1 $PINS A=n51 Y=n49
XU765 AOI21XL $PINS A0=n137 A1=n109 B0=n110 Y=n108
XU766 INVXL $PINS A=n132 Y=n130
XU767 AOI21X1 $PINS A0=n74 A1=n590 B0=n63 Y=n59
XU768 AND2X2 $PINS A=n112 B=n114 Y=n600
XU769 XOR2X1 $PINS A=n126 B=n601 Y=product[25]
XU770 XNOR2X2 $PINS A=n144 B=n13 Y=product[23]
XU771 OAI21XL $PINS A0=FE_DBTN166_n166 A1=n145 B0=n146 Y=n144
XU772 INVXL $PINS A=n131 Y=n129
XU773 AOI21XL $PINS A0=n74 A1=n49 B0=n50 Y=n48
XU774 INVX1 $PINS A=n52 Y=n50
XU775 NAND2X1 $PINS A=n590 B=n589 Y=n51
XU776 NAND2XL $PINS A=n73 B=n42 Y=n40
XU777 NAND2X1 $PINS A=n320 B=n325 Y=n105
XU778 INVX1 $PINS A=n179 Y=n276
XU779 INVX1 $PINS A=n95 Y=n93
XU780 INVXL $PINS A=n149 Y=n147
XU781 INVX1 $PINS A=n65 Y=n63
XU782 AOI21XL $PINS A0=n74 A1=n42 B0=n43 Y=n41
XU783 OAI21XL $PINS A0=n97 A1=n47 B0=n48 Y=n46
XU784 OAI21XL $PINS A0=n97 A1=n40 B0=n41 Y=n39
XU785 INVX1 $PINS A=n36 Y=n34
XU786 OAI21XL $PINS A0=n41 A1=n37 B0=n38 Y=n36
XU787 NOR2X1 $PINS A=n319 B=n314 Y=n95
XU788 NOR2X1 $PINS A=n313 B=n308 Y=n88
XU789 NOR2X1 $PINS A=n302 B=n307 Y=n79
XU790 NAND2X1 $PINS A=n319 B=n314 Y=n96
XU791 NAND2X1 $PINS A=n302 B=n307 Y=n80
XU792 NAND2X1 $PINS A=n298 B=n301 Y=n65
XU793 NAND2X1 $PINS A=n313 B=n308 Y=n89
XU794 NAND2X1 $PINS A=n585 B=n213 Y=n24
XU795 ADDFX2 $PINS A=n329 B=n327 CI=n322 S=n320 CO=n319
XU796 ADDFX2 $PINS A=n346 B=n351 CI=n344 S=n342 CO=n341
XU797 INVX1 $PINS A=n213 Y=n211
XU798 NOR2X1 $PINS A=n293 B=n292 Y=n44
XU799 NOR2X1 $PINS A=n291 B=FE_RN_1 Y=n37
XU800 NAND2X1 $PINS A=n291 B=FE_RN_1 Y=n38
XU801 NAND2X1 $PINS A=n463 B=a[1] Y=n241
XU802 ADDFX2 $PINS A=FE_DBTN184_n6772 B=n309 CI=n304 S=n302 CO=n301
XU803 ADDFX2 $PINS A=FE_OFN5803_n6772 B=n300 CI=n303 S=n298 CO=n297
XU804 XNOR2X1 $PINS A=a[16] B=a[18] Y=n300
XU805 ADDFX2 $PINS A=n323 B=n316 CI=n321 S=n314 CO=n313
XU806 OR2XL $PINS A=a[16] B=a[12] Y=n323
XU807 ADDFX2 $PINS A=p10 B=n315 CI=n310 S=n308 CO=n307
XU808 ADDFX2 $PINS A=_register_0_17 B=FE_RN_1 CI=n299 S=n294 CO=n293
XU809 OR2XL $PINS A=a[16] B=a[18] Y=n299
XU810 ADDFX2 $PINS A=a[10] B=a[2] CI=a[6] S=n402 CO=n401
XU811 ADDFX2 $PINS A=n363 B=n356 CI=n361 S=n352 CO=n351
XU812 XNOR2X1 $PINS A=a[18] B=a[10] Y=n356
XU813 OR2X2 $PINS A=_register_0_17 B=a[9] Y=n363
XU814 OR2XL $PINS A=a[18] B=a[10] Y=n355
XU815 XNOR2XL $PINS A=a[19] B=p7 Y=n348
XU816 ADDFX2 $PINS A=a[19] B=FE_OFN388_register_0__11 CI=n337 S=n328 CO=n327
XU817 CMPR32X1 $PINS A=a[9] B=FE_OCPN6224_register_0__13 C=_register_0_17
+ S=n346 CO=n345
XU818 XNOR2X1 $PINS A=n32 B=a[19] Y=product[35]
XU819 OAI21XL $PINS A0=n97 A1=n591 B0=n34 Y=n32
XU820 XNOR2X1 $PINS A=a[19] B=a[18] Y=n292
XU822 OR2X2 $PINS A=a[19] B=a[18] Y=n291
XU826 ADDFX2 $PINS A=_register_0_3 B=a[5] CI=p6 S=n442 CO=n441
XU538 AOI2BB1X4 $PINS A0N=n603 A1N=FE_DBTN166_n166 B0=n99 Y=n97
XU828 OR2X2 $PINS A=n138 B=n100 Y=n603
.ENDS

.SUBCKT CONV_DW01_add_6 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
*.CONNECT SUM[0] B[0]
XFE_OCPC2301_n211 CLKBUFX8 $PINS A=FE_OCPN6204_n211 Y=FE_OCPN6205_n211
XFE_OCPC2300_n211 BUFX3 $PINS A=n210 Y=FE_OCPN6204_n211
XFE_OCPC2299_n211 INVX8 $PINS A=n211 Y=n210
XFE_OCPC2268_n211 CLKBUFX3 $PINS A=n211 Y=FE_OCPN6180_n211
XFE_RC_507_0 AOI21X4 $PINS A0=n212 A1=n266 B0=n213 Y=n211
XFE_OFC2232_n287 INVX1 $PINS A=n287 Y=n286
XFE_OFC1054_n266 CLKINVX3 $PINS A=n266 Y=n265
XFE_OFC975_n184 INVX4 $PINS A=n184 Y=n178
XFE_OFC596_n296 INVX1 $PINS A=n296 Y=n295
XFE_OFC247_n13 INVX1 $PINS A=n13 Y=n450
XFE_OFC243_n488 INVX1 $PINS A=n488 Y=n489
XFE_DBTC165_n238 INVX1 $PINS A=n238 Y=FE_DBTN165_n238
XU6 XOR2X2 $PINS A=n47 B=n2 Y=SUM[34]
XU68 NOR2X2 $PINS A=A[30] B=B[30] Y=n85
XU92 NOR2X2 $PINS A=n116 B=n107 Y=n105
XU98 XOR2X4 $PINS A=n118 B=n9 Y=SUM[27]
XU108 NOR2X2 $PINS A=A[27] B=B[27] Y=n116
XU124 NOR2X2 $PINS A=A[26] B=B[26] Y=n129
XU142 NOR2X2 $PINS A=n183 B=n145 Y=n143
XU144 NAND2X4 $PINS A=n165 B=n147 Y=n145
XU146 NOR2X4 $PINS A=n156 B=n149 Y=n147
XU150 NOR2X4 $PINS A=A[24] B=B[24] Y=n149
XU160 NOR2X2 $PINS A=A[23] B=B[23] Y=n156
XU170 NOR2X4 $PINS A=n174 B=n167 Y=n165
XU174 NOR2X4 $PINS A=A[22] B=B[22] Y=n167
XU236 OAI21X4 $PINS A0=n214 A1=n245 B0=n215 Y=n213
XU237 NAND2X4 $PINS A=n230 B=n216 Y=n214
XU238 AOI21X4 $PINS A0=n216 A1=n231 B0=n217 Y=n215
XU239 NOR2X2 $PINS A=n218 B=n223 Y=n216
XU243 NOR2X4 $PINS A=B[16] B=A[16] Y=n218
XU259 NOR2X2 $PINS A=n237 B=n232 Y=n230
XU263 NOR2X4 $PINS A=A[14] B=B[14] Y=n232
XU281 NOR2X2 $PINS A=n253 B=n248 Y=n246
XU285 NOR2X2 $PINS A=B[12] B=A[12] Y=n248
XU303 NOR2X2 $PINS A=A[10] B=B[10] Y=n260
XU374 OAI21XL $PINS A0=n162 A1=n156 B0=n157 Y=n153
XU375 AOI2BB1X1 $PINS A0N=n287 A1N=n284 B0=n283 Y=n281
XU376 OAI21XL $PINS A0=n104 A1=n57 B0=n58 Y=n56
XU377 NAND2X1 $PINS A=n490 B=n59 Y=n57
XU378 NAND2X2 $PINS A=A[25] B=B[25] Y=n137
XU379 XOR2X4 $PINS A=n131 B=n10 Y=SUM[26]
XU380 NAND2X2 $PINS A=n127 B=n105 Y=n103
XU383 NAND2X1 $PINS A=n158 B=n450 Y=n451
XU384 NAND2X2 $PINS A=n449 B=n13 Y=n452
XU385 NAND2X4 $PINS A=n451 B=n452 Y=SUM[23]
XU386 INVX1 $PINS A=n158 Y=n449
XU388 AOI21X2 $PINS A0=FE_OCPN6205_n211 A1=n159 B0=n160 Y=n158
XU389 NAND2BX1 $PINS AN=n156 B=n157 Y=n13
XU390 OR2X2 $PINS A=n167 B=n175 Y=n453
XU391 NAND2X4 $PINS A=n453 B=n168 Y=n166
XU392 AOI21X4 $PINS A0=n147 A1=n166 B0=n148 Y=n146
XU393 OR2X2 $PINS A=n184 B=n174 Y=n454
XU394 NAND2X1 $PINS A=n454 B=n175 Y=n171
XU395 AOI21X1 $PINS A0=FE_OCPN6204_n211 A1=n170 B0=n171 Y=n169
XU396 NAND2X1 $PINS A=A[21] B=B[21] Y=n175
XU397 XOR2X2 $PINS A=n250 B=n24 Y=SUM[12]
XU398 AOI21X1 $PINS A0=n255 A1=n251 B0=n252 Y=n250
XU399 XOR2X2 $PINS A=n138 B=n11 Y=SUM[25]
XU400 NOR2X1 $PINS A=A[3] B=B[3] Y=n293
XU402 NAND2X1 $PINS A=n68 B=n101 Y=n66
XU403 AOI21X1 $PINS A0=n102 A1=n68 B0=n69 Y=n67
XU405 XNOR2X1 $PINS A=n286 B=n31 Y=SUM[5]
XU406 NAND2X1 $PINS A=A[24] B=B[24] Y=n150
XU407 NAND2X1 $PINS A=A[18] B=B[18] Y=n204
XU409 NOR2X1 $PINS A=n183 B=n174 Y=n170
XU410 NAND2X2 $PINS A=n201 B=n185 Y=n183
XU412 NAND2X1 $PINS A=A[10] B=B[10] Y=n261
XU414 INVX1 $PINS A=n208 Y=n206
XU415 NOR2X2 $PINS A=A[17] B=B[17] Y=n208
XU416 NOR2X1 $PINS A=A[13] B=B[13] Y=n237
XU417 OAI21XL $PINS A0=n297 A1=n300 B0=n298 Y=n296
XU418 NAND2X1 $PINS A=A[30] B=B[30] Y=n86
XU419 NAND2X1 $PINS A=A[17] B=B[17] Y=n209
XU420 NAND2X1 $PINS A=A[2] B=B[2] Y=n298
XU421 NAND2X1 $PINS A=A[1] B=B[1] Y=n300
XU422 INVX1 $PINS A=n202 Y=n463
XU423 NAND2X1 $PINS A=A[14] B=B[14] Y=n233
XU424 NAND2X1 $PINS A=A[13] B=B[13] Y=n238
XU425 AOI21X1 $PINS A0=n286 A1=n277 B0=n278 Y=n276
XU426 NAND2X1 $PINS A=A[29] B=B[29] Y=n95
XU427 NOR2X2 $PINS A=A[31] B=B[31] Y=n72
XU428 NAND2X1 $PINS A=n206 B=n209 Y=n19
XU429 XNOR2X2 $PINS A=n262 B=n26 Y=SUM[10]
XU430 OAI21XL $PINS A0=n142 A1=n121 B0=n126 Y=n120
XU431 NAND2BX1 $PINS AN=n174 B=n175 Y=n15
XU432 NAND2BX2 $PINS AN=n256 B=n246 Y=n244
XU433 NAND2BXL $PINS AN=n61 B=n62 Y=n4
XU434 AND2X1 $PINS A=n73 B=n305 Y=n478
XU436 XOR2X2 $PINS A=n169 B=n14 Y=SUM[22]
XU437 NAND2BX1 $PINS AN=n149 B=n150 Y=n12
XU438 NAND2BX1 $PINS AN=n129 B=n130 Y=n10
XU439 NAND2BX1 $PINS AN=n194 B=n195 Y=n17
XU440 AOI21X4 $PINS A0=n185 A1=n202 B0=n186 Y=n184
XU441 OAI21X2 $PINS A0=n210 A1=n19 B0=n462 Y=SUM[17]
XU442 NAND2BX1 $PINS AN=n293 B=n294 Y=n33
XU443 AOI21X4 $PINS A0=FE_OCPN6204_n211 A1=n181 B0=n178 Y=n176
XU445 AOI21X2 $PINS A0=n102 A1=n92 B0=n93 Y=n91
XU446 OAI2BB1X2 $PINS A0N=n468 A1N=n266 B0=n227 Y=n225
XU447 OAI21XL $PINS A0=n295 A1=n293 B0=n294 Y=n292
XU449 OAI2BB1X1 $PINS A0N=n266 A1N=n458 B0=n264 Y=n262
XU450 INVX1 $PINS A=n263 Y=n458
XU451 NAND2X1 $PINS A=n321 B=n224 Y=n21
XU452 INVX1 $PINS A=n223 Y=n321
XU453 OR2X1 $PINS A=n103 B=n142 Y=n464
XU454 NAND2BX1 $PINS AN=n290 B=n291 Y=n32
XU455 OAI21XL $PINS A0=n276 A1=n274 B0=n275 Y=n273
XU456 NAND2BX1 $PINS AN=n260 B=n261 Y=n26
XU457 NAND2BX1 $PINS AN=n187 B=n188 Y=n16
XU458 INVX2 $PINS A=n104 Y=n102
XU460 NAND2BX1 $PINS AN=n297 B=n298 Y=n34
XU461 NAND2BX1 $PINS AN=n263 B=n264 Y=n27
XU462 NOR2X1 $PINS A=n141 B=n121 Y=n119
XU463 INVX4 $PINS A=n143 Y=n141
XU464 OAI21X2 $PINS A0=n265 A1=n256 B0=n257 Y=n255
XU465 INVX1 $PINS A=n285 Y=n283
XU466 NAND2BXL $PINS AN=n232 B=n233 Y=n22
XU467 OAI2BB1X1 $PINS A0N=FE_OCPN6205_n211 A1N=n143 B0=n142 Y=n459
XU468 INVX1 $PINS A=n459 Y=n138
XU469 NOR2BX1 $PINS AN=n490 B=n72 Y=n68
XU470 OR2X2 $PINS A=n260 B=n263 Y=n256
XU471 NAND2BXL $PINS AN=n218 B=n219 Y=n20
XU472 NAND2BX1 $PINS AN=n274 B=n275 Y=n29
XU473 NAND2BX1 $PINS AN=n136 B=n137 Y=n11
XU474 OAI21XL $PINS A0=n279 A1=n285 B0=n280 Y=n278
XU475 OAI2BB1X4 $PINS A0N=n266 A1N=n475 B0=n245 Y=n239
XU476 CLKINVX3 $PINS A=n244 Y=n475
XU477 AOI21XL $PINS A0=n102 A1=n490 B0=n84 Y=n78
XU478 NOR2BX1 $PINS AN=n300 B=n299 Y=SUM[1]
XU479 NAND2BX1 $PINS AN=n248 B=n249 Y=n24
XU480 NAND2XL $PINS A=n114 B=n117 Y=n9
XU481 NAND2X2 $PINS A=n461 B=n249 Y=n247
XU482 NAND2X1 $PINS A=n101 B=n490 Y=n77
XU483 CLKINVX3 $PINS A=n103 Y=n101
XU484 NAND2X1 $PINS A=n282 B=n285 Y=n31
XU485 INVX1 $PINS A=n284 Y=n282
XU486 NOR2X1 $PINS A=n161 B=n156 Y=n152
XU487 NOR2BX1 $PINS AN=n201 B=n194 Y=n190
XU488 INVX1 $PINS A=n116 Y=n114
XU489 AOI31X1 $PINS A0=n52 A1=n467 A2=n466 B0=n479 Y=n38
XU490 NOR2X1 $PINS A=n141 B=n103 Y=n97
XU491 INVX1 $PINS A=n107 Y=n308
XU492 OAI21X1 $PINS A0=n218 A1=n224 B0=n219 Y=n217
XU493 XOR2X4 $PINS A=n151 B=n12 Y=SUM[24]
XU494 OAI21X4 $PINS A0=n267 A1=n287 B0=n268 Y=n266
XU495 NOR2X1 $PINS A=A[7] B=B[7] Y=n274
XU496 INVX2 $PINS A=n183 Y=n181
XU497 XNOR2X4 $PINS A=n225 B=n21 Y=SUM[15]
XU499 OR2X2 $PINS A=n232 B=n238 Y=n460
XU500 NAND2X2 $PINS A=n460 B=n233 Y=n231
XU501 OR2X2 $PINS A=n248 B=n254 Y=n461
XU502 NAND2X1 $PINS A=A[11] B=B[11] Y=n254
XU503 XOR2X1 $PINS A=n281 B=n30 Y=SUM[6]
XU504 NOR2X1 $PINS A=n293 B=n290 Y=n288
XU505 AOI21X4 $PINS A0=n178 A1=n165 B0=n166 Y=n162
XU506 NAND2X1 $PINS A=n101 B=n92 Y=n90
XU507 XNOR2X2 $PINS A=n74 B=n478 Y=SUM[31]
XU508 NOR2X1 $PINS A=A[5] B=B[5] Y=n284
XU509 NOR2X2 $PINS A=A[28] B=B[28] Y=n107
XU510 INVX1 $PINS A=n162 Y=n160
XU511 OAI21XL $PINS A0=n290 A1=n294 B0=n291 Y=n289
XU512 NAND2X1 $PINS A=A[3] B=B[3] Y=n294
XU513 NAND2X1 $PINS A=A[4] B=B[4] Y=n291
XU514 NOR2X2 $PINS A=n194 B=n187 Y=n185
XU515 AOI21X1 $PINS A0=n288 A1=n296 B0=n289 Y=n287
XU516 AOI21X2 $PINS A0=n132 A1=FE_OCPN6205_n211 B0=n133 Y=n131
XU517 AND2X2 $PINS A=n475 B=n230 Y=n468
XU518 NOR2X1 $PINS A=A[6] B=B[6] Y=n279
XU519 NAND2X1 $PINS A=A[6] B=B[6] Y=n280
XU520 NAND2X1 $PINS A=n181 B=n165 Y=n161
XU521 NAND2X1 $PINS A=A[12] B=B[12] Y=n249
XU522 INVX1 $PINS A=n253 Y=n251
XU523 OAI21XL $PINS A0=n142 A1=n112 B0=n113 Y=n111
XU524 NOR2X1 $PINS A=n141 B=n112 Y=n110
XU525 NAND2X1 $PINS A=A[28] B=B[28] Y=n108
XU526 NOR2X1 $PINS A=n141 B=n90 Y=n88
XU528 NAND2X1 $PINS A=n330 B=n280 Y=n30
XU529 INVX1 $PINS A=n279 Y=n330
XU530 NAND2X1 $PINS A=A[23] B=B[23] Y=n157
XU531 INVX1 $PINS A=n161 Y=n159
XU532 INVX1 $PINS A=n237 Y=n235
XU533 NOR2X2 $PINS A=A[25] B=B[25] Y=n136
XU534 INVX1 $PINS A=n84 Y=n82
XU535 NAND2X1 $PINS A=n210 B=n19 Y=n462
XU537 NOR2X1 $PINS A=n284 B=n279 Y=n277
XU538 NAND2X1 $PINS A=A[27] B=B[27] Y=n117
XU539 NOR2X2 $PINS A=n136 B=n129 Y=n127
XU540 XOR2X4 $PINS A=n87 B=n6 Y=SUM[30]
XU541 AOI21X2 $PINS A0=n239 A1=n235 B0=FE_DBTN165_n238 Y=n234
XU542 AOI21X1 $PINS A0=n55 A1=n144 B0=n56 Y=n54
XU543 XOR2X2 $PINS A=n220 B=n20 Y=SUM[16]
XU544 AOI21X2 $PINS A0=n225 A1=n321 B0=n222 Y=n220
XU545 OAI21XL $PINS A0=n271 A1=n275 B0=n272 Y=n270
XU546 INVX1 $PINS A=n245 Y=n243
XU547 NAND2X2 $PINS A=A[15] B=B[15] Y=n224
XU548 XOR2X4 $PINS A=n96 B=n7 Y=SUM[29]
XU549 INVX4 $PINS A=n144 Y=n142
XU550 NAND2X1 $PINS A=A[22] B=B[22] Y=n168
XU551 XOR2X4 $PINS A=n189 B=n16 Y=SUM[20]
XU552 OAI21X4 $PINS A0=FE_OCPN6180_n211 A1=n53 B0=n54 Y=n52
XU553 NOR2X1 $PINS A=n72 B=n61 Y=n59
XU554 NAND2X1 $PINS A=n464 B=n104 Y=n98
XU555 NOR2X2 $PINS A=B[15] B=A[15] Y=n223
XU556 OAI21X4 $PINS A0=n184 A1=n145 B0=n146 Y=n144
XU557 NOR2X1 $PINS A=A[32] B=B[32] Y=n61
XU558 NAND2X1 $PINS A=n466 B=n46 Y=n2
XU559 NOR2X1 $PINS A=A[2] B=B[2] Y=n297
XU560 AND2X2 $PINS A=n308 B=n108 Y=n477
XU561 NAND2X1 $PINS A=A[32] B=B[32] Y=n62
XU562 INVX1 $PINS A=n224 Y=n222
XU564 NAND2X1 $PINS A=A[7] B=B[7] Y=n275
XU565 AOI21X1 $PINS A0=n128 A1=n114 B0=n115 Y=n113
XU566 OAI21X2 $PINS A0=n129 A1=n137 B0=n130 Y=n128
XU568 NAND2X1 $PINS A=A[31] B=B[31] Y=n73
XU569 XOR2X1 $PINS A=n34 B=n300 Y=SUM[2]
XU570 NAND2X1 $PINS A=A[20] B=B[20] Y=n188
XU571 XOR2X1 $PINS A=n295 B=n33 Y=SUM[3]
XU572 XNOR2X1 $PINS A=n292 B=n32 Y=SUM[4]
XU573 INVX1 $PINS A=n127 Y=n121
XU574 NAND2X1 $PINS A=n92 B=n95 Y=n7
XU575 NAND2X1 $PINS A=n306 B=n86 Y=n6
XU576 AOI21X2 $PINS A0=FE_OCPN6205_n211 A1=n152 B0=n153 Y=n151
XU577 AOI21X1 $PINS A0=n243 A1=n230 B0=n231 Y=n227
XU578 OR2X2 $PINS A=A[34] B=B[34] Y=n466
XU579 OR2X2 $PINS A=A[33] B=B[33] Y=n467
XU580 NOR2X1 $PINS A=A[29] B=B[29] Y=n94
XU581 INVX1 $PINS A=n94 Y=n92
XU583 INVX1 $PINS A=n128 Y=n126
XU584 AOI21X2 $PINS A0=n64 A1=FE_OCPN6205_n211 B0=n65 Y=n63
XU585 XOR2X4 $PINS A=n255 B=n469 Y=SUM[11]
XU586 AND2X2 $PINS A=n251 B=n254 Y=n469
XU587 INVX1 $PINS A=n271 Y=n328
XU588 XOR2X1 $PINS A=n276 B=n29 Y=SUM[7]
XU589 NAND2X1 $PINS A=n143 B=n55 Y=n53
XU590 NAND2X1 $PINS A=n277 B=n269 Y=n267
XU591 NAND2X1 $PINS A=n328 B=n272 Y=n28
XU592 XOR2X2 $PINS A=n265 B=n27 Y=SUM[9]
XU594 OAI21X2 $PINS A0=n260 A1=n264 B0=n261 Y=n259
XU595 OR2XL $PINS A=A[22] B=B[22] Y=n471
XU596 NOR2X1 $PINS A=n103 B=n57 Y=n55
XU597 AOI21X1 $PINS A0=n52 A1=n467 B0=n49 Y=n47
XU598 OAI21X1 $PINS A0=n142 A1=n136 B0=n137 Y=n133
XU599 INVX1 $PINS A=n259 Y=n257
XU600 NOR2X1 $PINS A=n141 B=n136 Y=n132
XU602 AOI21X2 $PINS A0=n88 A1=FE_OCPN6205_n211 B0=n89 Y=n87
XU603 OAI21XL $PINS A0=n463 A1=n194 B0=n195 Y=n191
XU604 AOI21X4 $PINS A0=n246 A1=n259 B0=n247 Y=n245
XU606 AOI21X2 $PINS A0=n210 A1=n201 B0=n202 Y=n196
XU607 XOR2X4 $PINS A=n63 B=n4 Y=SUM[32]
XU608 XOR2X4 $PINS A=n196 B=n17 Y=SUM[19]
XU609 OAI21X4 $PINS A0=n203 A1=n209 B0=n204 Y=n202
XU610 AOI21X2 $PINS A0=n210 A1=n206 B0=n207 Y=n205
XU612 AOI21X2 $PINS A0=n210 A1=n190 B0=n191 Y=n189
XU613 NOR2X2 $PINS A=n208 B=n203 Y=n201
XU614 AOI21X4 $PINS A0=n105 A1=n128 B0=n106 Y=n104
XU615 NOR2X1 $PINS A=A[9] B=B[9] Y=n263
XU616 NOR2X2 $PINS A=A[21] B=B[21] Y=n174
XU617 AOI21X2 $PINS A0=n97 A1=FE_OCPN6205_n211 B0=n98 Y=n96
XU618 AOI21X1 $PINS A0=n75 A1=FE_OCPN6205_n211 B0=n76 Y=n74
XU620 OAI21X1 $PINS A0=n142 A1=n90 B0=n91 Y=n89
XU621 AOI21X2 $PINS A0=FE_OCPN6205_n211 A1=n119 B0=n120 Y=n118
XU622 XOR2X4 $PINS A=n176 B=n15 Y=SUM[21]
XU623 XOR2X2 $PINS A=n234 B=n22 Y=SUM[14]
XU624 NOR2X1 $PINS A=A[11] B=B[11] Y=n253
XU625 NOR2X2 $PINS A=n214 B=n244 Y=n212
XU626 AOI21X2 $PINS A0=n110 A1=FE_OCPN6205_n211 B0=n111 Y=n109
XU627 XNOR2X4 $PINS A=n109 B=n477 Y=SUM[28]
XU628 NAND2X1 $PINS A=A[9] B=B[9] Y=n264
XU629 OR2X2 $PINS A=n187 B=n195 Y=n473
XU630 NAND2X2 $PINS A=n473 B=n188 Y=n186
XU631 NOR2X4 $PINS A=A[20] B=B[20] Y=n187
XU632 NAND2X2 $PINS A=A[19] B=B[19] Y=n195
XU633 XNOR2X1 $PINS A=n273 B=n28 Y=SUM[8]
XU634 XOR2X4 $PINS A=n205 B=n18 Y=SUM[18]
XU635 NOR2X2 $PINS A=A[8] B=B[8] Y=n271
XU636 NAND2X1 $PINS A=A[8] B=B[8] Y=n272
XU637 NOR2X1 $PINS A=n274 B=n271 Y=n269
XU638 XOR2X4 $PINS A=n239 B=n476 Y=SUM[13]
XU639 NOR2X2 $PINS A=A[19] B=B[19] Y=n194
XU640 NOR2X2 $PINS A=A[18] B=B[18] Y=n203
XU641 NOR2X1 $PINS A=A[4] B=B[4] Y=n290
XU642 AOI21X1 $PINS A0=n269 A1=n278 B0=n270 Y=n268
XU643 XOR2X1 $PINS A=n38 B=n1 Y=SUM[35]
XU644 NAND2XL $PINS A=A[35] B=B[35] Y=n37
XU645 NAND2X1 $PINS A=n471 B=n168 Y=n14
XU646 INVXL $PINS A=n209 Y=n207
XU647 NAND2X1 $PINS A=A[26] B=B[26] Y=n130
XU648 OAI21XL $PINS A0=n82 A1=n72 B0=n73 Y=n69
XU649 AOI21X1 $PINS A0=n59 A1=n84 B0=n60 Y=n58
XU650 OAI21X1 $PINS A0=n107 A1=n117 B0=n108 Y=n106
XU651 NAND2XL $PINS A=A[34] B=B[34] Y=n46
XU652 NAND2X1 $PINS A=A[5] B=B[5] Y=n285
XU653 NAND2XL $PINS A=A[33] B=B[33] Y=n51
XU654 NOR2XL $PINS A=A[1] B=B[1] Y=n299
XU655 NOR2XL $PINS A=n141 B=n77 Y=n75
XU657 OAI21X1 $PINS A0=n149 A1=n157 B0=n150 Y=n148
XU658 NAND2X1 $PINS A=n127 B=n114 Y=n112
XU659 NAND2X1 $PINS A=n318 B=n204 Y=n18
XU660 INVX1 $PINS A=n203 Y=n318
XU661 INVX1 $PINS A=n117 Y=n115
XU662 INVXL $PINS A=n85 Y=n306
XU663 NAND2X1 $PINS A=B[16] B=A[16] Y=n219
XU664 INVX1 $PINS A=n95 Y=n93
XU665 OAI21XL $PINS A0=n61 A1=n73 B0=n62 Y=n60
XU666 INVXL $PINS A=n72 Y=n305
XU667 OAI21XL $PINS A0=n142 A1=n66 B0=n67 Y=n65
XU668 INVX1 $PINS A=n254 Y=n252
XU669 OAI2BB1X1 $PINS A0N=n466 A1N=n49 B0=n46 Y=n479
XU670 XOR2X2 $PINS A=n52 B=n480 Y=SUM[33]
XU671 AND2X2 $PINS A=n467 B=n51 Y=n480
XU672 INVX1 $PINS A=n51 Y=n49
XU673 NAND2X1 $PINS A=n481 B=n37 Y=n1
XU674 OR2X2 $PINS A=A[35] B=B[35] Y=n481
XU593 OR2X2 $PINS A=n85 B=n95 Y=n483
XU619 NAND2X1 $PINS A=n483 B=n86 Y=n84
XU656 NOR2BX1 $PINS AN=n235 B=FE_DBTN165_n238 Y=n476
XU677 OR2X2 $PINS A=n142 B=n77 Y=n486
XU678 NAND2X1 $PINS A=n486 B=n78 Y=n76
XU680 OR2X2 $PINS A=n141 B=n103 Y=n488
XU681 AND2X2 $PINS A=n68 B=n489 Y=n64
XU683 NOR2X2 $PINS A=n94 B=n85 Y=n490
.ENDS

.SUBCKT CONV_DW_mult_uns_31_0 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[13] b[12]
+ b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0] product[33]
+ product[32] product[31] product[30] product[29] product[28] product[27]
+ product[26] product[25] product[24] product[23] product[22] product[21]
+ product[20] product[19] product[18] product[17] product[16] product[15]
+ product[14] product[13] product[12] product[11] product[10] product[9]
+ product[8] product[7] product[6] product[5] product[4] product[3] product[2]
+ product[1] product[0] _register_1_11 n4988 FE_OFN55_register_1__6
+ FE_OFN57_register_1__13
*.CONNECT FE_RN_1 a[2]
*.CONNECT product[33] n30
XFE_OCPC2330_N1144 BUFX12 $PINS A=a[1] Y=FE_OCPN6234_N1144
XFE_RC_655_0 OAI21X1 $PINS A0=n123 A1=n115 B0=n116 Y=n114
XFE_RC_529_0 NAND2BX1 $PINS AN=n15 B=FE_OFN5420_n157 Y=FE_RN_290_0
XFE_RC_528_0 INVX1 $PINS A=n15 Y=FE_RN_291_0
XFE_RC_527_0 OAI21X4 $PINS A0=FE_OFN5420_n157 A1=FE_RN_291_0 B0=FE_RN_290_0
+ Y=product[18]
XFE_RC_516_0 INVX1 $PINS A=n199 Y=FE_RN_284_0
XFE_RC_515_0 INVX1 $PINS A=n211 Y=FE_RN_285_0
XFE_RC_514_0 OAI2BB1X2 $PINS A0N=FE_RN_285_0 A1N=FE_RN_284_0 B0=n200 Y=n198
XFE_OFC2067_n150 INVX1 $PINS A=n150 Y=n144
XFE_OFC2003_register_1__17 BUFX3 $PINS A=a[17] Y=FE_OFN6031_register_1__17
XFE_OFC1804_n133 INVXL $PINS A=n133 Y=n239
XFE_OFC1466_n196 INVX1 $PINS A=n194 Y=FE_OFN5708_n196
XFE_OFC1465_n196 INVX1 $PINS A=n196 Y=n194
XFE_OFC1103_n157 INVX8 $PINS A=n157 Y=FE_OFN5420_n157
XU64 XNOR2X4 $PINS A=n85 B=n6 Y=product[27]
XU92 XNOR2X4 $PINS A=n106 B=n9 Y=product[24]
XU128 XNOR2X4 $PINS A=n135 B=n12 Y=product[21]
XU135 AOI21X4 $PINS A0=n131 A1=n150 B0=n132 Y=n130
XU136 NOR2X2 $PINS A=n140 B=n133 Y=n131
XU140 NOR2X2 $PINS A=n309 B=n302 Y=n133
XU161 OAI21X4 $PINS A0=n151 A1=n155 B0=n152 Y=n150
XU164 NOR2X2 $PINS A=n318 B=n325 Y=n151
XU183 XOR2X4 $PINS A=n167 B=n17 Y=product[16]
XU263 OAI21X2 $PINS A0=n513 A1=n217 B0=n218 Y=n216
XU313 ADDFX2 $PINS A=n321 B=n319 CI=n312 S=n310 CO=n309
XU317 ADDFHX1 $PINS A=n329 B=n327 CI=n320 S=n318 CO=n317
XU382 XNOR2X2 $PINS A=n183 B=n20 Y=product[13]
XU383 AOI21X1 $PINS A0=n128 A1=n113 B0=n114 Y=n108
XU384 OR2X2 $PINS A=n178 B=n519 Y=n506
XU385 AOI22X1 $PINS A0=n394 A1=n397 B0=n212 B1=n216 Y=n211
XU386 XNOR2X1 $PINS A=n205 B=n516 Y=product[10]
XU387 AND2X2 $PINS A=n508 B=n209 Y=n205
XU389 OAI21X2 $PINS A0=FE_OFN5420_n157 A1=n147 B0=n144 Y=n142
XU391 OAI21X2 $PINS A0=FE_OFN5420_n157 A1=n154 B0=n155 Y=n153
XU392 NAND2X1 $PINS A=n522 B=n113 Y=n107
XU393 NAND2X1 $PINS A=n318 B=n325 Y=n152
XU394 NAND2X1 $PINS A=n310 B=n317 Y=n141
XU395 AOI21X2 $PINS A0=n198 A1=n179 B0=n180 Y=n178
XU396 OAI21XL $PINS A0=n71 A1=n67 B0=n68 Y=n64
XU397 AOI21X1 $PINS A0=n82 A1=n502 B0=n75 Y=n71
XU398 ADDHXL $PINS A=a[14] B=a[12] S=n278 CO=n277
XU402 NAND2X1 $PINS A=a[3] B=a[0] Y=n228
XU404 ADDFX2 $PINS A=a[7] B=a[4] CI=n396 S=n394 CO=n393
XU405 ADDHXL $PINS A=FE_OCPN6234_N1144 B=a[0] S=n396 CO=n395
XU406 NOR2X1 $PINS A=n181 B=n184 Y=n179
XU407 AND2X2 $PINS A=n160 B=n168 Y=n493
XU408 AOI21X1 $PINS A0=n207 A1=n499 B0=n202 Y=n200
XU410 OR2X2 $PINS A=n386 B=n389 Y=n499
XU411 NOR2X1 $PINS A=n104 B=n95 Y=n93
XU412 INVX1 $PINS A=n189 Y=n187
XU413 XNOR2X2 $PINS A=n69 B=n4 Y=product[29]
XU414 XNOR2X2 $PINS A=n97 B=n8 Y=product[25]
XU415 OAI21XL $PINS A0=FE_OFN5420_n157 A1=n98 B0=n99 Y=n97
XU416 NAND2XL $PINS A=n141 B=n138 Y=n13
XU417 XNOR2X2 $PINS A=n190 B=n21 Y=product[12]
XU418 AND2X2 $PINS A=n350 B=n357 Y=n510
XU419 INVX1 $PINS A=n209 Y=n207
XU420 INVX1 $PINS A=n204 Y=n202
XU421 NAND2BX1 $PINS AN=n225 B=n226 Y=n28
XU422 NAND2BX1 $PINS AN=n95 B=n96 Y=n8
XU423 AOI21X1 $PINS A0=n138 A1=n150 B0=n139 Y=n137
XU424 INVXL $PINS A=n140 Y=n138
XU425 INVXL $PINS A=n141 Y=n139
XU426 XNOR3X2 $PINS A=n513 B=n398 C=a[0] Y=product[7]
XU427 NAND2BX1 $PINS AN=n67 B=n68 Y=n4
XU428 NAND2BX1 $PINS AN=n115 B=n116 Y=n10
XU429 INVX1 $PINS A=n214 Y=n212
XU430 NOR2BX1 $PINS AN=n113 B=n104 Y=n100
XU431 NAND2BX1 $PINS AN=n154 B=n155 Y=n15
XU432 NAND2X1 $PINS A=n366 B=n373 Y=n182
XU433 XOR3X2 $PINS A=n216 B=n394 C=n397 Y=product[8]
XU434 NAND2BX1 $PINS AN=n151 B=n152 Y=n14
XU435 NAND2BX1 $PINS AN=n86 B=n87 Y=n7
XU436 NOR2X1 $PINS A=n70 B=n67 Y=n63
XU437 NOR2BX1 $PINS AN=n176 B=n519 Y=n515
XU438 XNOR2X2 $PINS A=n124 B=n11 Y=product[22]
XU439 NAND2X1 $PINS A=n386 B=n389 Y=n204
XU440 XNOR2X1 $PINS A=n350 B=n357 Y=n18
XU441 AND2X2 $PINS A=n228 B=n489 Y=product[4]
XU442 INVX1 $PINS A=n227 Y=n489
XU443 XOR2X2 $PINS A=n36 B=a[19] Y=product[32]
XU444 OAI21X2 $PINS A0=FE_OFN5420_n157 A1=n107 B0=n108 Y=n106
XU445 NAND2X1 $PINS A=FE_RN_285_0 B=n503 Y=n508
XU446 XNOR2X1 $PINS A=n366 B=n373 Y=n20
XU447 XNOR2X2 $PINS A=n60 B=n3 Y=product[30]
XU448 NAND2BX1 $PINS AN=n104 B=n105 Y=n9
XU449 NAND2X1 $PINS A=n149 B=n131 Y=n129
XU450 AOI2BB1X1 $PINS A0N=n130 A1N=n122 B0=n121 Y=n119
XU451 AOI221X1 $PINS A0=n518 A1=n82 B0=n75 B1=n43 C0=n44 Y=n38
XU452 OAI21X1 $PINS A0=n167 A1=n165 B0=n166 Y=n164
XU453 NOR2X1 $PINS A=n129 B=n91 Y=n89
XU455 XNOR2X4 $PINS A=n78 B=n5 Y=product[28]
XU456 OAI21XL $PINS A0=n95 A1=n105 B0=n96 Y=n94
XU457 OAI21X1 $PINS A0=n88 A1=n70 B0=n71 Y=n69
XU458 ADDFX2 $PINS A=a[5] B=a[3] CI=a[8] S=n348 CO=n347
XU459 ADDFX2 $PINS A=a[8] B=a[6] CI=_register_1_11 S=n324 CO=n323
XU461 ADDFX2 $PINS A=a[8] B=a[14] CI=_register_1_11 S=n354 CO=n353
XU462 ADDFX2 $PINS A=a[18] B=a[12] CI=a[15] S=n322 CO=n321
XU463 ADDHXL $PINS A=_register_1_11 B=a[9] S=n300 CO=n299
XU464 ADDFX2 $PINS A=a[14] B=a[15] CI=a[18] S=n298 CO=n297
XU465 ADDFX2 $PINS A=a[10] B=a[4] CI=a[7] S=n382 CO=n381
XU466 ADDFX2 $PINS A=a[12] B=n372 CI=n377 S=n368 CO=n367
XU467 ADDFX2 $PINS A=a[8] B=n395 CI=n392 S=n390 CO=n389
XU468 ADDFX2 $PINS A=a[18] B=a[17] CI=n278 S=n276 CO=n275
XU469 ADDFX2 $PINS A=a[19] B=a[18] CI=n272 S=n270 CO=n269
XU470 ADDFX2 $PINS A=n298 B=n296 CI=n303 S=n294 CO=n293
XU471 NAND2X1 $PINS A=n334 B=n341 Y=n163
XU472 NAND2X1 $PINS A=n380 B=n385 Y=n196
XU473 AOI21X1 $PINS A0=n224 A1=n490 B0=n221 Y=n513
XU474 OR2X2 $PINS A=n390 B=n393 Y=n503
XU475 NOR2X1 $PINS A=n67 B=n45 Y=n43
XU476 NAND2X1 $PINS A=n113 B=n93 Y=n91
XU477 NAND2X1 $PINS A=n342 B=n349 Y=n166
XU479 NAND2X1 $PINS A=n309 B=n302 Y=n134
XU480 NOR2X1 $PINS A=n293 B=n286 Y=n115
XU481 ADDFX2 $PINS A=n290 B=n295 CI=n288 S=n286 CO=n285
XU482 NOR2X1 $PINS A=n279 B=n274 Y=n95
XU483 NAND2X1 $PINS A=n279 B=n274 Y=n96
XU484 OAI21X2 $PINS A0=n88 A1=n79 B0=n80 Y=n78
XU485 XNOR2X2 $PINS A=n142 B=n13 Y=product[20]
XU486 NAND2X1 $PINS A=n280 B=n285 Y=n105
XU487 OAI21XL $PINS A0=n88 A1=n37 B0=n38 Y=n36
XU488 XNOR2X2 $PINS A=n51 B=n2 Y=product[31]
XU489 OAI21XL $PINS A0=n88 A1=n52 B0=n53 Y=n51
XU490 INVX4 $PINS A=n178 Y=n177
XU491 OR2X2 $PINS A=a[5] B=FE_RN_1 Y=n490
XU492 INVX1 $PINS A=n130 Y=n128
XU493 OR2X2 $PINS A=n374 B=n379 Y=n491
XU494 OR2X2 $PINS A=n380 B=n385 Y=n492
XU495 OAI2BB1X4 $PINS A0N=n493 A1N=n177 B0=n159 Y=n157
XU496 XOR2X1 $PINS A=a[3] B=a[6] Y=n494
XU497 XOR2X1 $PINS A=FE_RN_1 B=n494 Y=n388
XU498 XNOR2X1 $PINS A=n197 B=n517 Y=product[11]
XU499 ADDFX2 $PINS A=n284 B=n287 CI=n282 S=n280 CO=n279
XU500 NOR2X1 $PINS A=n394 B=n397 Y=n214
XU501 OAI21X1 $PINS A0=n225 A1=n228 B0=n226 Y=n224
XU502 NAND2X1 $PINS A=n273 B=n268 Y=n87
XU503 NOR2X1 $PINS A=n264 B=n267 Y=n83
XU505 ADDFX2 $PINS A=_register_1_11 B=a[8] CI=n383 S=n376 CO=n375
XU507 OAI21X2 $PINS A0=n88 A1=n86 B0=n87 Y=n85
XU508 OAI21X1 $PINS A0=n133 A1=n141 B0=n134 Y=n132
XU509 NOR2X1 $PINS A=n310 B=n317 Y=n140
XU510 OAI21X1 $PINS A0=FE_OFN5420_n157 A1=n129 B0=n130 Y=n124
XU511 AND2X1 $PINS A=n499 B=n204 Y=n516
XU512 NAND2XL $PINS A=a[3] B=FE_RN_1 Y=n495
XU513 NAND2XL $PINS A=a[6] B=FE_RN_1 Y=n496
XU514 NAND2XL $PINS A=a[6] B=a[3] Y=n497
XU515 NAND3X1 $PINS A=n497 B=n495 C=n496 Y=n387
XU516 ADDFX2 $PINS A=FE_RN_1 B=FE_OCPN6234_N1144 CI=a[5] S=n392 CO=n391
XU518 XOR2X4 $PINS A=n172 B=n18 Y=product[15]
XU519 NAND2X1 $PINS A=n499 B=n503 Y=n199
XU520 NAND2XL $PINS A=n81 B=n518 Y=n37
XU522 ADDFX2 $PINS A=a[4] B=FE_RN_1 CI=a[7] S=n356 CO=n355
XU523 ADDFX2 $PINS A=a[6] B=a[4] CI=a[9] S=n340 CO=n339
XU524 ADDFX2 $PINS A=a[7] B=a[5] CI=a[10] S=n332 CO=n331
XU525 ADDFX2 $PINS A=a[19] B=FE_OFN57_register_1__13 CI=a[16] S=n314 CO=n313
XU526 ADDFX2 $PINS A=a[9] B=a[7] CI=a[12] S=n316 CO=n315
XU527 ADDFX2 $PINS A=a[3] B=FE_OCPN6234_N1144 CI=a[6] S=n364 CO=n363
XU528 ADDFX2 $PINS A=FE_OFN57_register_1__13 B=a[7] CI=a[10] S=n362 CO=n361
XU529 ADDFX2 $PINS A=n504 B=n369 CI=n362 S=n360 CO=n359
XU530 ADDFX2 $PINS A=a[15] B=a[9] CI=a[12] S=n346 CO=n345
XU531 ADDFX2 $PINS A=a[17] B=_register_1_11 CI=a[14] S=n330 CO=n329
XU532 ADDFHX1 $PINS A=n331 B=n322 CI=n324 S=n320 CO=n319
XU533 ADDHXL $PINS A=a[10] B=a[8] S=n308 CO=n307
XU534 ADDFX2 $PINS A=a[14] B=FE_OFN57_register_1__13 CI=a[17] S=n306 CO=n305
XU535 ADDHXL $PINS A=a[12] B=a[10] S=n292 CO=n291
XU536 XOR2X1 $PINS A=FE_RN_1 B=a[0] Y=n372
XU537 ADDFX2 $PINS A=a[6] B=a[5] CI=a[9] S=n370 CO=n369
XU538 ADDFX2 $PINS A=a[19] B=a[14] CI=a[16] S=n266 CO=n265
XU540 ADDHXL $PINS A=a[6] B=a[3] S=n398 CO=n397
XU541 ADDFX2 $PINS A=a[17] B=_register_1_11 CI=FE_OFN57_register_1__13 S=n284
+ CO=n283
XU542 ADDFX2 $PINS A=n283 B=n276 CI=n281 S=n274 CO=n273
XU543 NOR2X1 $PINS A=n398 B=a[0] Y=n217
XU544 XNOR2X2 $PINS A=n164 B=n16 Y=product[17]
XU546 XOR2X1 $PINS A=n28 B=n228 Y=product[5]
XU547 INVX1 $PINS A=n114 Y=n112
XU548 AOI21X1 $PINS A0=n128 A1=n100 B0=n101 Y=n99
XU549 OAI21XL $PINS A0=n112 A1=n104 B0=n105 Y=n101
XU550 NAND2X1 $PINS A=n491 B=n189 Y=n21
XU551 AND2X2 $PINS A=n492 B=FE_OFN5708_n196 Y=n517
XU552 INVX1 $PINS A=n82 Y=n80
XU553 NOR2X1 $PINS A=n273 B=n268 Y=n86
XU554 AND2X2 $PINS A=n506 B=n176 Y=n172
XU555 NAND2X1 $PINS A=n120 B=n123 Y=n11
XU557 NAND2X1 $PINS A=n490 B=n223 Y=n27
XU558 OR2X2 $PINS A=n259 B=n258 Y=n498
XU559 OR2X2 $PINS A=n38 B=n4988 Y=n500
XU560 OR2X2 $PINS A=n257 B=a[18] Y=n501
XU561 OR2X2 $PINS A=n263 B=n262 Y=n502
XU564 NOR2X1 $PINS A=n301 B=n294 Y=n122
XU565 NOR2X1 $PINS A=n280 B=n285 Y=n104
XU566 AND2X2 $PINS A=FE_RN_1 B=a[0] Y=n504
XU567 NAND2X1 $PINS A=n358 B=n365 Y=n176
XU568 OR2X2 $PINS A=n37 B=n4988 Y=n505
XU569 ADDFHX1 $PINS A=n347 B=n338 CI=n340 S=n336 CO=n335
XU570 OAI21XL $PINS A0=n197 A1=n184 B0=n185 Y=n183
XU571 ADDFX2 $PINS A=n363 B=n354 CI=n356 S=n352 CO=n351
XU572 NAND2X1 $PINS A=n522 B=n120 Y=n118
XU573 NAND2X1 $PINS A=a[5] B=FE_RN_1 Y=n223
XU574 XNOR2X1 $PINS A=n224 B=n27 Y=product[6]
XU575 CLKINVX3 $PINS A=n198 Y=n197
XU576 NAND2BX1 $PINS AN=n165 B=n166 Y=n17
XU577 XNOR2X4 $PINS A=n153 B=n14 Y=product[19]
XU578 NAND2X1 $PINS A=a[4] B=FE_OCPN6234_N1144 Y=n226
XU579 ADDFX2 $PINS A=a[4] B=FE_OCPN6234_N1144 CI=a[5] S=n378 CO=n377
XU581 XOR2X2 $PINS A=n88 B=n7 Y=product[26]
XU582 ADDFX2 $PINS A=n355 B=n346 CI=n348 S=n344 CO=n343
XU583 NAND2X1 $PINS A=n293 B=n286 Y=n116
XU584 OAI21XL $PINS A0=n88 A1=n61 B0=n62 Y=n60
XU585 NAND2XL $PINS A=n239 B=n134 Y=n12
XU586 AOI21X1 $PINS A0=n64 A1=n498 B0=n57 Y=n53
XU587 ADDFHX2 $PINS A=n361 B=n359 CI=n352 S=n350 CO=n349
XU588 ADDFX2 $PINS A=n337 B=n335 CI=n328 S=n326 CO=n325
XU589 NAND2X1 $PINS A=n301 B=n294 Y=n123
XU590 NOR2X1 $PINS A=n170 B=n176 Y=n509
XU591 AOI21X2 $PINS A0=n160 A1=n169 B0=n161 Y=n159
XU592 XNOR2X4 $PINS A=n117 B=n10 Y=product[23]
XU593 NAND2X1 $PINS A=n522 B=n100 Y=n98
XU595 NOR2X1 $PINS A=n86 B=n83 Y=n81
XU596 NAND2X1 $PINS A=n81 B=n502 Y=n70
XU597 INVX1 $PINS A=n81 Y=n79
XU598 OAI21XL $PINS A0=n185 A1=n181 B0=n182 Y=n180
XU599 ADDFX2 $PINS A=n364 B=n367 CI=n360 S=n358 CO=n357
XU601 OAI21XL $PINS A0=n83 A1=n87 B0=n84 Y=n82
XU602 NAND2X1 $PINS A=n390 B=n393 Y=n209
XU603 NAND2X1 $PINS A=n503 B=n209 Y=n24
XU604 NAND2X1 $PINS A=n374 B=n379 Y=n189
XU606 NOR2X1 $PINS A=n122 B=n115 Y=n113
XU607 OAI21XL $PINS A0=n162 A1=n166 B0=n163 Y=n161
XU608 AOI21X1 $PINS A0=n491 A1=n194 B0=n187 Y=n185
XU609 NOR2X2 $PINS A=n170 B=n519 Y=n168
XU610 NOR2X1 $PINS A=a[4] B=FE_OCPN6234_N1144 Y=n225
XU611 NOR2X1 $PINS A=n366 B=n373 Y=n181
XU612 OR2X2 $PINS A=n509 B=n510 Y=n169
XU613 AOI21X4 $PINS A0=n177 A1=n168 B0=n169 Y=n167
XU614 OAI21X2 $PINS A0=n197 A1=n191 B0=FE_OFN5708_n196 Y=n190
XU615 AOI21X4 $PINS A0=n89 A1=n157 B0=n90 Y=n88
XU616 OAI21X1 $PINS A0=n130 A1=n91 B0=n92 Y=n90
XU617 NOR2X2 $PINS A=n162 B=n165 Y=n160
XU618 NOR2X2 $PINS A=n342 B=n349 Y=n165
XU619 NAND2X1 $PINS A=n491 B=n492 Y=n184
XU620 ADDFX2 $PINS A=n384 B=n387 CI=n382 S=n380 CO=n379
XU621 NOR2X2 $PINS A=n350 B=n357 Y=n170
XU622 ADDFX2 $PINS A=a[9] B=n391 CI=n388 S=n386 CO=n385
XU623 NOR2X2 $PINS A=n334 B=n341 Y=n162
XU624 ADDFHX2 $PINS A=n353 B=n351 CI=n344 S=n342 CO=n341
XU625 ADDFX2 $PINS A=n381 B=n378 CI=n376 S=n374 CO=n373
XU626 ADDFHX1 $PINS A=n345 B=n343 CI=n336 S=n334 CO=n333
XU627 ADDFX2 $PINS A=a[15] B=a[16] CI=a[19] S=n290 CO=n289
XU628 NAND2XL $PINS A=n502 B=n77 Y=n5
XU629 NOR2X2 $PINS A=n326 B=n333 Y=n154
XU630 NAND2X2 $PINS A=n326 B=n333 Y=n155
XU631 INVX1 $PINS A=n77 Y=n75
XU632 ADDFX2 $PINS A=a[16] B=a[10] CI=FE_OFN57_register_1__13 S=n338 CO=n337
XU633 XOR2X2 $PINS A=n177 B=n515 Y=product[14]
XU634 NAND2BXL $PINS AN=n162 B=n163 Y=n16
XU635 NOR2X1 $PINS A=n154 B=n151 Y=n149
XU636 NAND2BXL $PINS AN=n83 B=n84 Y=n6
XU637 INVXL $PINS A=n123 Y=n121
XU638 XNOR2X1 $PINS A=FE_RN_285_0 B=n24 Y=product[9]
XU639 NAND2XL $PINS A=n498 B=n59 Y=n3
XU640 ADDFX2 $PINS A=n370 B=n375 CI=n368 S=n366 CO=n365
XU641 NAND2XL $PINS A=n501 B=n50 Y=n2
XU642 ADDFX2 $PINS A=n306 B=n304 CI=n311 S=n302 CO=n301
XU643 NAND2XL $PINS A=n398 B=a[0] Y=n218
XU644 NOR2XL $PINS A=a[3] B=a[0] Y=n227
XU646 NAND2X1 $PINS A=n63 B=n498 Y=n52
XU648 INVX1 $PINS A=n149 Y=n147
XU649 INVX1 $PINS A=n63 Y=n61
XU651 AOI21X1 $PINS A0=n114 A1=n93 B0=n94 Y=n92
XU652 INVX1 $PINS A=n122 Y=n120
XU653 INVX1 $PINS A=n64 Y=n62
XU654 INVX1 $PINS A=n492 Y=n191
XU655 AND2X2 $PINS A=n43 B=n502 Y=n518
XU656 NAND2X1 $PINS A=n264 B=n267 Y=n84
XU657 OAI21XL $PINS A0=n68 A1=n45 B0=n46 Y=n44
XU658 NAND2X1 $PINS A=n498 B=n501 Y=n45
XU659 OAI21XL $PINS A0=n88 A1=n505 B0=n500 Y=n30
XU660 INVX1 $PINS A=n59 Y=n57
XU661 INVX1 $PINS A=n223 Y=n221
XU662 ADDFX2 $PINS A=n271 B=n266 CI=n269 S=n264 CO=n263
XU663 ADDFX2 $PINS A=n277 B=n275 CI=n270 S=n268 CO=n267
XU664 ADDFX2 $PINS A=n308 B=n315 CI=n313 S=n304 CO=n303
XU665 ADDFX2 $PINS A=n300 B=n307 CI=n305 S=n296 CO=n295
XU666 ADDFX2 $PINS A=n339 B=n330 CI=n332 S=n328 CO=n327
XU667 ADDFX2 $PINS A=n323 B=n314 CI=n316 S=n312 CO=n311
XU668 ADDFX2 $PINS A=n292 B=n299 CI=n297 S=n288 CO=n287
XU669 NOR2X1 $PINS A=n261 B=n260 Y=n67
XU670 NAND2X1 $PINS A=n261 B=n260 Y=n68
XU671 NAND2X1 $PINS A=n263 B=n262 Y=n77
XU672 NAND2X1 $PINS A=n259 B=n258 Y=n59
XU673 AOI21X1 $PINS A0=n501 A1=n57 B0=n48 Y=n46
XU674 INVX1 $PINS A=n50 Y=n48
XU675 ADDHXL $PINS A=a[15] B=FE_OFN57_register_1__13 S=n272 CO=n271
XU676 ADDFX2 $PINS A=a[16] B=n291 CI=n289 S=n282 CO=n281
XU677 ADDHXL $PINS A=a[3] B=a[0] S=n384 CO=n383
XU678 ADDHXL $PINS A=a[18] B=a[16] S=n260 CO=n259
XU679 ADDHXL $PINS A=a[19] B=FE_OFN6031_register_1__17 S=n258 CO=n257
XU680 ADDFX2 $PINS A=a[17] B=a[15] CI=n265 S=n262 CO=n261
XU681 NAND2XL $PINS A=n257 B=a[18] Y=n50
XU388 NOR2X1 $PINS A=n358 B=n365 Y=n519
XU521 OAI2BB1X1 $PINS A0N=n157 A1N=n520 B0=n137 Y=n135
XU545 AND2X2 $PINS A=n149 B=n138 Y=n520
XU556 OR2X2 $PINS A=FE_OFN5420_n157 B=n118 Y=n521
XU683 NAND2X4 $PINS A=n521 B=n119 Y=n117
XU684 AND2X2 $PINS A=n149 B=n131 Y=n522
.ENDS

.SUBCKT CONV_DW_mult_uns_49_0 a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12]
+ a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[14] b[13]
+ b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0]
+ product[34] product[33] product[32] product[31] product[30] product[29]
+ product[28] product[27] product[26] product[25] product[24] product[23]
+ product[22] product[21] product[20] product[19] product[18] product[17]
+ product[16] product[15] product[14] product[13] product[12] product[11]
+ product[10] product[9] product[8] product[7] product[6] product[5] product[4]
+ product[3] product[2] product[1] product[0] p1 p2 p3 p4 p5 p6 p7 p8 p9 p10
+ p11 p12 p13 p14 p15 p16 p17 p18 p19 p20 FE_OFN6_register_8__12
+ FE_OFN10_register_8__3 FE_OFN11_N1424 FE_OFN16_register_8__9 FE_OFN20_N1034
+ FE_OFN18_N1034 FE_OFN22_register_8__14 FE_OFN24_register_8__16
+ FE_OFN29_register_8__17 FE_OFN40_register_8__19 FE_OFN46_register_8__18
+ FE_OFN53_register_8__12 _register_8_6 p21 p22 FE_OFN64_register_8__8
+ FE_OFN65_register_8__11 FE_OFN70_register_8__2 FE_OFN75_register_8__18
+ FE_OFN82_register_8__19 FE_OFN87_register_8__16 FE_OFN88_register_8__15
+ FE_OFN96_n FE_OFN102_n
XFE_OFC1681_register_8__18 BUFX3 $PINS A=a[18] Y=FE_OFN5821_register_8__18
XFE_OFC1619_register_8__9 INVX1 $PINS A=a[9] Y=FE_OFN5791_register_8__9
XFE_OFC1576_register_8__7 INVX1 $PINS A=a[7] Y=FE_OFN5769_register_8__7
XFE_OFC1477_register_8__13 INVX1 $PINS A=p14 Y=FE_OFN5715_register_8__13
XFE_OFC1400_n178 INVX1 $PINS A=n177 Y=FE_OFN5673_n178
XFE_OFC1399_n178 CLKINVX3 $PINS A=n178 Y=n177
XFE_OFC1385_register_8__10 INVX1 $PINS A=a[10] Y=FE_OFN5665_register_8__10
XFE_OFC334_n237 INVX1 $PINS A=n237 Y=FE_DBTN163_n237
XFE_OFC262_n255 INVX1 $PINS A=n255 Y=n588
XFE_OFC194_n592 INVX1 $PINS A=n592 Y=n252
XFE_DBTC164_n75 INVX1 $PINS A=n75 Y=FE_DBTN164_n75
XU464 ADDFX2 $PINS A=FE_OFN70_register_8__2 B=FE_OFN53_register_8__12 CI=a[7]
+ S=n431 CO=n430
XU467 AOI21XL $PINS A0=FE_DBTN163_n237 A1=n227 B0=n228 Y=n226
XU468 NAND2X1 $PINS A=FE_OFN5673_n178 B=n568 Y=n569
XU469 NAND2X1 $PINS A=n569 B=n140 Y=n138
XU471 INVX1 $PINS A=n139 Y=n568
XU473 AOI21XL $PINS A0=n149 A1=n141 B0=n142 Y=n140
XU474 XNOR2X1 $PINS A=n138 B=n12 Y=product[23]
XU477 OAI21XL $PINS A0=n183 A1=n187 B0=n184 Y=n182
XU478 ADDHXL $PINS A=FE_OFN88_register_8__15 B=p12 S=n337 CO=n336
XU480 ADDFX2 $PINS A=n380 B=n369 CI=n376 S=n367 CO=n366
XU481 OAI21XL $PINS A0=n191 A1=n197 B0=n192 Y=n190
XU482 NAND2X1 $PINS A=n383 B=n390 Y=n176
XU483 INVX1 $PINS A=n225 Y=n223
XU485 NOR2X1 $PINS A=n449 B=n450 Y=n243
XU486 AOI21X1 $PINS A0=n75 A1=n43 B0=n44 Y=n42
XU487 NOR2X1 $PINS A=n161 B=n154 Y=n152
XU488 AOI32X1 $PINS A0=n574 A1=n315 A2=n320 B0=n309 B1=n314 Y=n77
XU489 NAND2XL $PINS A=n391 B=n398 Y=n184
XU490 OAI221XL $PINS A0=FE_DBTN164_n75 A1=n52 B0=n109 B1=n48 C0=n53 Y=n47
XU491 AOI32X1 $PINS A0=n575 A1=n332 A2=n327 B0=n321 B1=n326 Y=n97
XU492 NAND2BX1 $PINS AN=n175 B=n176 Y=n17
XU494 NAND2BX1 $PINS AN=n172 B=n173 Y=n16
XU495 NOR3BX1 $PINS AN=n258 B=n255 C=n252 Y=n580
XU496 AOI21X2 $PINS A0=n110 A1=FE_OFN5673_n178 B0=n111 Y=n109
XU497 OAI2BB2X1 $PINS A0N=n451 A1N=a[0] B0=n249 B1=n247 Y=n246
XU498 NAND2BX1 $PINS AN=n183 B=n184 Y=n18
XU500 NAND2BX1 $PINS AN=n154 B=n155 Y=n14
XU501 OAI21XL $PINS A0=n240 A1=n244 B0=n241 Y=n239
XU502 NOR2BX1 $PINS AN=n134 B=n125 Y=n121
XU503 OAI221XL $PINS A0=n97 A1=n572 B0=n109 B1=n83 C0=n90 Y=n82
XU504 INVX1 $PINS A=n578 Y=n572
XU505 NAND2XL $PINS A=n159 B=n162 Y=n15
XU506 NOR2X1 $PINS A=n332 B=n327 Y=n107
XU507 XOR3X2 $PINS A=n47 B=n300 C=n299 Y=product[32]
XU508 NAND2BX1 $PINS AN=n186 B=n187 Y=n19
XU509 OAI21XL $PINS A0=n589 A1=n125 B0=n126 Y=n122
XU511 NAND2BX1 $PINS AN=n252 B=n253 Y=n31
XU512 NAND2BX1 $PINS AN=n229 B=n230 Y=n26
XU513 NAND2BX1 $PINS AN=n38 B=n39 Y=n2
XU514 OAI21XL $PINS A0=n177 A1=n168 B0=n165 Y=n163
XU515 INVXL $PINS A=n171 Y=n165
XU516 INVXL $PINS A=n151 Y=n149
XU517 NAND2BX1 $PINS AN=n216 B=n577 Y=n205
XU518 NAND2BX1 $PINS AN=n96 B=n578 Y=n83
XU519 XNOR3X2 $PINS A=n451 B=a[0] C=n249 Y=product[5]
XU520 AOI21XL $PINS A0=n159 A1=n171 B0=n160 Y=n158
XU521 NAND2BX1 $PINS AN=n255 B=n256 Y=n32
XU522 NAND2BXL $PINS AN=n136 B=n137 Y=n12
XU523 AOI22X1 $PINS A0=n304 A1=n301 B0=n64 B1=n576 Y=n53
XU524 XOR3X2 $PINS A=n246 B=n449 C=n450 Y=product[6]
XU525 OAI21XL $PINS A0=n109 A1=n107 B0=n108 Y=n102
XU526 XOR3X2 $PINS A=n428 B=n423 C=n204 Y=product[13]
XU528 NOR2BX1 $PINS AN=n126 B=n125 Y=n582
XU529 NOR2X1 $PINS A=n383 B=n390 Y=n175
XU530 NAND2BX1 $PINS AN=n191 B=n192 Y=n20
XU531 XOR3X2 $PINS A=n219 B=n435 C=n438 Y=product[11]
XU532 NOR2BX1 $PINS AN=n241 B=n240 Y=n581
XU533 XOR3X2 $PINS A=n58 B=n304 C=n301 Y=product[31]
XU534 NOR2BX1 $PINS AN=n117 B=n116 Y=n583
XU535 NAND2X1 $PINS A=n351 B=n358 Y=n144
XU536 ADDFX2 $PINS A=n355 B=n360 CI=n353 S=n351 CO=n350
XU537 OAI21XL $PINS A0=n252 A1=n256 B0=n253 Y=n251
XU538 XOR2X1 $PINS A=n231 B=n26 Y=product[9]
XU540 NAND2X1 $PINS A=n170 B=n152 Y=n150
XU541 INVX1 $PINS A=n199 Y=n198
XU542 ADDFX2 $PINS A=FE_OFN5715_register_8__13 B=a[4] CI=p17 S=n403 CO=n402
XU543 ADDHXL $PINS A=FE_OFN20_N1034 B=FE_OFN5769_register_8__7 S=n441 CO=n440
XU546 ADDFX2 $PINS A=FE_OFN5821_register_8__18 B=a[13] CI=p12 S=n349 CO=n348
XU548 ADDFX2 $PINS A=n413 B=n416 CI=n409 S=n407 CO=n406
XU549 ADDFX2 $PINS A=a[19] B=a[14] CI=FE_OFN6_register_8__12 S=n343 CO=n342
XU550 ADDFX2 $PINS A=a[13] B=FE_OFN40_register_8__19 CI=n337 S=n335 CO=n334
XU551 AOI21X1 $PINS A0=n198 A1=n189 B0=n190 Y=n188
XU552 NOR2X1 $PINS A=n451 B=p1 Y=n247
XU553 NOR2X1 $PINS A=n580 B=n251 Y=n249
XU554 ADDFX2 $PINS A=n386 B=n384 CI=n377 S=n375 CO=n374
XU555 NOR2X1 $PINS A=n191 B=n196 Y=n189
XU556 ADDFX2 $PINS A=n342 B=n335 CI=n340 S=n333 CO=n332
XU557 NAND2X1 $PINS A=a[3] B=FE_OFN18_N1034 Y=n256
XU558 NAND2X1 $PINS A=n449 B=n450 Y=n244
XU559 INVX1 $PINS A=n246 Y=n245
XU560 OAI21XL $PINS A0=n229 A1=n235 B0=n230 Y=n228
XU561 NOR2X1 $PINS A=n234 B=n229 Y=n227
XU562 AOI21X1 $PINS A0=n198 A1=n194 B0=n195 Y=n193
XU563 XNOR2X1 $PINS A=n174 B=n16 Y=product[19]
XU564 XNOR2X1 $PINS A=n156 B=n14 Y=product[21]
XU566 OR2X2 $PINS A=n439 B=n442 Y=n573
XU567 NOR2X1 $PINS A=n407 B=n414 Y=n191
XU568 XNOR2X1 $PINS A=a[5] B=FE_OFN70_register_8__2 Y=n451
XU569 NOR2X1 $PINS A=n260 B=a[2] Y=n258
XU570 CMPR32X1 $PINS A=_register_8_6 B=FE_OFN102_n C=p5 S=n443 CO=n442
XU571 INVX1 $PINS A=n258 Y=n257
XU572 XNOR2X1 $PINS A=n198 B=n21 Y=product[14]
XU573 NOR2X1 $PINS A=n366 B=n359 Y=n154
XU574 XNOR2X1 $PINS A=n91 B=n7 Y=product[28]
XU575 OAI21XL $PINS A0=n109 A1=n96 B0=n97 Y=n91
XU576 XOR2X1 $PINS A=n67 B=n584 Y=product[30]
XU577 OAI21XL $PINS A0=n109 A1=n68 B0=FE_DBTN164_n75 Y=n67
XU578 ADDFX2 $PINS A=p15 B=n421 CI=n426 S=n417 CO=n416
XU579 ADDFX2 $PINS A=a[12] B=p4 CI=p16 S=n411 CO=n410
XU580 ADDFX2 $PINS A=n420 B=n418 CI=n411 S=n409 CO=n408
XU581 ADDHXL $PINS A=FE_OFN20_N1034 B=FE_OFN5791_register_8__9 S=n433 CO=n432
XU582 ADDFX2 $PINS A=p4 B=p14 CI=n432 S=n425 CO=n424
XU583 ADDFX2 $PINS A=FE_OFN11_N1424 B=FE_OFN5665_register_8__10 CI=p9 S=n427
+ CO=n426
XU586 ADDFX2 $PINS A=p18 B=FE_OFN87_register_8__16 CI=FE_OFN88_register_8__15
+ S=n323 CO=n322
XU587 ADDFX2 $PINS A=a[15] B=FE_OFN96_n CI=p21 S=n387 CO=n386
XU588 ADDFX2 $PINS A=n396 B=n387 CI=n389 S=n385 CO=n384
XU589 ADDFX2 $PINS A=n388 B=n379 CI=n381 S=n377 CO=n376
XU591 ADDFX2 $PINS A=FE_OFN24_register_8__16 B=p8 CI=FE_OFN82_register_8__19
+ S=n379 CO=n378
XU592 ADDFX2 $PINS A=p11 B=FE_OFN96_n CI=p22 S=n371 CO=n370
XU594 ADDFX2 $PINS A=n433 B=n436 CI=n431 S=n429 CO=n428
XU595 ADDFX2 $PINS A=n430 B=n427 CI=n425 S=n423 CO=n422
XU596 NOR2X1 $PINS A=n423 B=n428 Y=n202
XU597 ADDFX2 $PINS A=p4 B=p7 CI=p2 S=n449 CO=n448
XU598 NOR2X1 $PINS A=n447 B=n448 Y=n240
XU599 OAI21XL $PINS A0=n188 A1=n186 B0=n187 Y=n185
XU600 OR2X2 $PINS A=a[19] B=p11 Y=n356
XU601 OAI21XL $PINS A0=n151 A1=n112 B0=n113 Y=n111
XU602 AOI21X1 $PINS A0=n577 A1=n215 B0=n208 Y=n206
XU603 INVX1 $PINS A=n210 Y=n208
XU604 NAND2X1 $PINS A=n447 B=n448 Y=n241
XU605 XOR2X1 $PINS A=n102 B=n585 Y=product[27]
XU606 AOI21X1 $PINS A0=n152 A1=n171 B0=n153 Y=n151
XU607 OAI21XL $PINS A0=n154 A1=n162 B0=n155 Y=n153
XU608 NOR2X1 $PINS A=n150 B=n112 Y=n110
XU610 OR2X2 $PINS A=n309 B=n314 Y=n574
XU611 OR2X2 $PINS A=n321 B=n326 Y=n575
XU612 OR2X2 $PINS A=n304 B=n301 Y=n576
XU613 OR2X2 $PINS A=n429 B=n434 Y=n577
XU614 OAI21XL $PINS A0=n97 A1=n76 B0=n77 Y=n75
XU616 OR2X2 $PINS A=n315 B=n320 Y=n578
XU617 OR2X2 $PINS A=n305 B=n308 Y=n579
XU620 NOR2X1 $PINS A=n96 B=n76 Y=n74
XU621 INVX1 $PINS A=n217 Y=n215
XU622 INVX1 $PINS A=n150 Y=n148
XU629 OAI21XL $PINS A0=n177 A1=n175 B0=n176 Y=n174
XU630 OAI21XL $PINS A0=n172 A1=n176 B0=n173 Y=n171
XU631 XNOR2X1 $PINS A=a[19] B=p11 Y=n357
XU632 NOR2X1 $PINS A=n143 B=n136 Y=n134
XU633 NAND2BX1 $PINS AN=a[1] B=a[0] Y=n260
XU634 AOI21X1 $PINS A0=n228 A1=n573 B0=n223 Y=n221
XU635 ADDFX2 $PINS A=p4 B=p8 CI=FE_OFN53_register_8__12 S=n397 CO=n396
XU636 AOI21X1 $PINS A0=n238 A1=n246 B0=n239 Y=n237
XU637 NOR2X1 $PINS A=n443 B=n444 Y=n229
XU638 NOR2X1 $PINS A=a[3] B=FE_OFN18_N1034 Y=n255
XU639 OAI21XL $PINS A0=n179 A1=n199 B0=n180 Y=n178
XU640 NOR2XL $PINS A=n243 B=n240 Y=n238
XU641 OAI21X1 $PINS A0=n237 A1=n220 B0=n221 Y=n219
XU643 NAND2XL $PINS A=n439 B=n442 Y=n225
XU646 NAND2XL $PINS A=p5 B=a[1] Y=n253
XU647 OAI21XL $PINS A0=n206 A1=n202 B0=n203 Y=n201
XU648 NOR2X1 $PINS A=n175 B=n172 Y=n170
XU649 XOR2X1 $PINS A=n242 B=n581 Y=product[7]
XU650 AOI21X1 $PINS A0=FE_DBTN163_n237 A1=n232 B0=n233 Y=n231
XU651 NAND2X1 $PINS A=n366 B=n359 Y=n155
XU652 NOR2X1 $PINS A=n375 B=n382 Y=n172
XU653 NAND2XL $PINS A=n105 B=n108 Y=n9
XU654 XOR2X1 $PINS A=n109 B=n9 Y=product[26]
XU655 OR2X2 $PINS A=n41 B=n38 Y=n586
XU658 AOI21XL $PINS A0=n149 A1=n134 B0=n135 Y=n129
XU659 NAND2XL $PINS A=n74 B=n50 Y=n48
XU660 NAND2XL $PINS A=n170 B=n159 Y=n157
XU661 NAND2XL $PINS A=n148 B=n141 Y=n139
XU662 NAND2XL $PINS A=n148 B=n121 Y=n119
XU663 NAND2XL $PINS A=n74 B=n579 Y=n59
XU664 OAI21XL $PINS A0=n218 A1=n216 B0=n217 Y=n211
XU665 AOI21X1 $PINS A0=n181 A1=n190 B0=n182 Y=n180
XU666 AOI21X1 $PINS A0=n219 A1=n200 B0=n201 Y=n199
XU667 NOR2X1 $PINS A=n205 B=n202 Y=n200
XU668 NOR2X1 $PINS A=n183 B=n186 Y=n181
XU669 INVXL $PINS A=n197 Y=n195
XU670 INVXL $PINS A=n196 Y=n194
XU671 OAI21XL $PINS A0=n177 A1=n157 B0=n158 Y=n156
XU672 NAND2XL $PINS A=n141 B=n144 Y=n13
XU673 INVXL $PINS A=n162 Y=n160
XU674 INVXL $PINS A=n161 Y=n159
XU675 INVXL $PINS A=n143 Y=n141
XU676 AOI21XL $PINS A0=n75 A1=n579 B0=n64 Y=n60
XU677 NAND2XL $PINS A=n74 B=n43 Y=n41
XU678 NAND2XL $PINS A=n407 B=n414 Y=n192
XU679 INVXL $PINS A=n235 Y=n233
XU680 INVXL $PINS A=n234 Y=n232
XU681 NAND2XL $PINS A=n375 B=n382 Y=n173
XU682 XOR2X1 $PINS A=n127 B=n582 Y=product[24]
XU683 XOR2X1 $PINS A=n118 B=n583 Y=product[25]
XU684 NAND2XL $PINS A=n350 B=n345 Y=n137
XU685 AND2X1 $PINS A=n579 B=n66 Y=n584
XU686 AND2X1 $PINS A=n575 B=n101 Y=n585
XU687 NAND2XL $PINS A=n578 B=n90 Y=n7
XU688 NOR2XL $PINS A=n52 B=n45 Y=n43
XU689 ADDFX2 $PINS A=n402 B=n400 CI=n393 S=n391 CO=n390
XU690 NAND2XL $PINS A=n309 B=n314 Y=n81
XU691 XNOR2XL $PINS A=p18 B=a[8] Y=n373
XU692 OR2XL $PINS A=p18 B=a[8] Y=n372
XU693 CMPR32X1 $PINS A=a[19] B=a[14] C=p18 S=n311 CO=n310
XU695 NAND2X1 $PINS A=n148 B=n134 Y=n128
XU696 INVX1 $PINS A=n74 Y=n68
XU697 INVX1 $PINS A=n170 Y=n168
XU698 INVX1 $PINS A=n52 Y=n50
XU699 NAND2X1 $PINS A=n181 B=n189 Y=n179
XU700 NAND2X1 $PINS A=n105 B=n575 Y=n96
XU701 NAND2X1 $PINS A=n134 B=n114 Y=n112
XU702 INVX1 $PINS A=n144 Y=n142
XU703 XNOR2X1 $PINS A=n163 B=n15 Y=product[20]
XU704 XNOR2X1 $PINS A=n145 B=n13 Y=product[22]
XU705 OAI21XL $PINS A0=n177 A1=n150 B0=n151 Y=n145
XU706 XNOR2X1 $PINS A=n185 B=n18 Y=product[17]
XU707 XNOR2X1 $PINS A=n211 B=n23 Y=product[12]
XU708 NAND2X1 $PINS A=n577 B=n210 Y=n23
XU709 NAND2X1 $PINS A=n194 B=n197 Y=n21
XU710 OAI21XL $PINS A0=n218 A1=n205 B0=n206 Y=n204
XU711 XOR2X1 $PINS A=n177 B=n17 Y=product[18]
XU712 XOR2X1 $PINS A=n188 B=n19 Y=product[16]
XU713 XOR2X1 $PINS A=n193 B=n20 Y=product[15]
XU715 INVX1 $PINS A=n219 Y=n218
XU716 NAND2X1 $PINS A=n578 B=n574 Y=n76
XU717 NAND2X1 $PINS A=n579 B=n576 Y=n52
XU718 NOR2X1 $PINS A=n367 B=n374 Y=n161
XU719 NOR2X1 $PINS A=n351 B=n358 Y=n143
XU720 NOR2X1 $PINS A=n415 B=n422 Y=n196
XU721 NOR2X1 $PINS A=n391 B=n398 Y=n183
XU722 NOR2X1 $PINS A=n350 B=n345 Y=n136
XU723 NOR2X1 $PINS A=n399 B=n406 Y=n186
XU724 NAND2X1 $PINS A=n227 B=n573 Y=n220
XU725 NAND2X1 $PINS A=n367 B=n374 Y=n162
XU726 NAND2X1 $PINS A=n415 B=n422 Y=n197
XU727 NOR2X1 $PINS A=n125 B=n116 Y=n114
XU728 NAND2X1 $PINS A=n399 B=n406 Y=n187
XU729 NAND2X1 $PINS A=n429 B=n434 Y=n210
XU730 NAND2X1 $PINS A=n423 B=n428 Y=n203
XU731 AOI21X1 $PINS A0=n135 A1=n114 B0=n115 Y=n113
XU732 OAI21XL $PINS A0=n116 A1=n126 B0=n117 Y=n115
XU733 AOI21XL $PINS A0=n149 A1=n121 B0=n122 Y=n120
XU734 XNOR2X1 $PINS A=a[1] B=a[0] Y=product[1]
XU735 OAI21XL $PINS A0=n177 A1=n128 B0=n129 Y=n127
XU736 OAI21XL $PINS A0=n177 A1=n119 B0=n120 Y=n118
XU737 XNOR2X1 $PINS A=n82 B=n6 Y=product[29]
XU738 NAND2X1 $PINS A=n574 B=n81 Y=n6
XU739 OAI21XL $PINS A0=n109 A1=n59 B0=n60 Y=n58
XU740 OAI21XL $PINS A0=n245 A1=n243 B0=n244 Y=n242
XU741 XNOR2X1 $PINS A=FE_DBTN163_n237 B=n27 Y=product[8]
XU742 NAND2X1 $PINS A=n232 B=n235 Y=n27
XU743 XOR2X1 $PINS A=n226 B=n25 Y=product[10]
XU744 NAND2X1 $PINS A=n573 B=n225 Y=n25
XU745 INVX1 $PINS A=n107 Y=n105
XU746 OAI21XL $PINS A0=n53 A1=n45 B0=n46 Y=n44
XU747 XNOR2X1 $PINS A=n40 B=n2 Y=product[33]
XU748 OAI21XL $PINS A0=n109 A1=n41 B0=n42 Y=n40
XU749 INVX1 $PINS A=n37 Y=n35
XU750 OAI21XL $PINS A0=n42 A1=n38 B0=n39 Y=n37
XU751 INVX1 $PINS A=n66 Y=n64
XU752 NOR2X1 $PINS A=n344 B=n339 Y=n125
XU753 NOR2X1 $PINS A=n445 B=n446 Y=n234
XU754 NOR2X1 $PINS A=n338 B=n333 Y=n116
XU755 NOR2X1 $PINS A=n435 B=n438 Y=n216
XU756 NAND2X1 $PINS A=n445 B=n446 Y=n235
XU757 NAND2X1 $PINS A=n344 B=n339 Y=n126
XU758 NAND2X1 $PINS A=n435 B=n438 Y=n217
XU759 NAND2X1 $PINS A=n332 B=n327 Y=n108
XU760 NAND2X1 $PINS A=n443 B=n444 Y=n230
XU761 NAND2X1 $PINS A=n338 B=n333 Y=n117
XU762 ADDFX2 $PINS A=a[11] B=n440 CI=n437 S=n435 CO=n434
XU763 ADDFX2 $PINS A=n394 B=n392 CI=n385 S=n383 CO=n382
XU764 ADDFX2 $PINS A=n419 B=n424 CI=n417 S=n415 CO=n414
XU765 ADDFX2 $PINS A=n410 B=n408 CI=n401 S=n399 CO=n398
XU766 ADDFX2 $PINS A=n336 B=n329 CI=n334 S=n327 CO=n326
XU767 ADDFX2 $PINS A=n363 B=n361 CI=n368 S=n359 CO=n358
XU768 ADDFX2 $PINS A=n354 B=n347 CI=n352 S=n345 CO=n344
XU769 XOR2X1 $PINS A=n260 B=a[2] Y=product[2]
XU770 XNOR2X1 $PINS A=n254 B=n31 Y=product[4]
XU772 XOR2X1 $PINS A=n257 B=n32 Y=product[3]
XU773 ADDFX2 $PINS A=n404 B=n395 CI=n397 S=n393 CO=n392
XU774 ADDFX2 $PINS A=n412 B=n403 CI=n405 S=n401 CO=n400
XU775 NAND2X1 $PINS A=n321 B=n326 Y=n101
XU776 NAND2X1 $PINS A=n315 B=n320 Y=n90
XU777 NAND2X1 $PINS A=n305 B=n308 Y=n66
XU778 NOR2X1 $PINS A=n300 B=n299 Y=n45
XU779 NOR2X1 $PINS A=n298 B=FE_OFN40_register_8__19 Y=n38
XU780 NAND2X1 $PINS A=n300 B=n299 Y=n46
XU781 NAND2X1 $PINS A=n298 B=FE_OFN40_register_8__19 Y=n39
XU782 ADDFX2 $PINS A=p14 B=n328 CI=n323 S=n321 CO=n320
XU783 ADDFX2 $PINS A=a[10] B=a[5] CI=n441 S=n439 CO=n438
XU784 ADDFX2 $PINS A=a[4] B=a[7] CI=p3 S=n447 CO=n446
XU785 ADDFX2 $PINS A=p6 B=FE_OFN64_register_8__8 CI=a[3] S=n445 CO=n444
XU786 OR2X2 $PINS A=a[5] B=FE_OFN70_register_8__2 Y=n450
XU787 ADDFX2 $PINS A=n373 B=n378 CI=n371 S=n369 CO=n368
XU788 ADDFX2 $PINS A=n372 B=n365 CI=n370 S=n361 CO=n360
XU789 XNOR2X1 $PINS A=FE_OFN5821_register_8__18 B=FE_OFN16_register_8__9 Y=n365
XU790 ADDFX2 $PINS A=a[14] B=p6 CI=a[17] S=n395 CO=n394
XU791 ADDFX2 $PINS A=FE_OFN11_N1424 B=a[8] CI=p7 S=n437 CO=n436
XU792 ADDFX2 $PINS A=p12 B=FE_OFN70_register_8__2 CI=FE_OFN102_n S=n419 CO=n418
XU794 ADDFX2 $PINS A=p8 B=p12 CI=a[16] S=n363 CO=n362
XU796 ADDFX2 $PINS A=a[8] B=FE_OFN6_register_8__12 CI=a[17] S=n355 CO=n354
XU797 ADDFX2 $PINS A=a[4] B=a[8] CI=p14 S=n389 CO=n388
XU798 ADDFX2 $PINS A=FE_OFN11_N1424 B=p6 CI=a[10] S=n413 CO=n412
XU799 ADDFX2 $PINS A=FE_OFN70_register_8__2 B=FE_OFN96_n
+ CI=FE_OFN65_register_8__11 S=n405 CO=n404
XU800 ADDHXL $PINS A=FE_OFN20_N1034 B=a[4] S=n421 CO=n420
XU801 ADDFX2 $PINS A=n364 B=n357 CI=n362 S=n353 CO=n352
XU802 OR2X2 $PINS A=FE_OFN5821_register_8__18 B=FE_OFN16_register_8__9 Y=n364
XU803 ADDFX2 $PINS A=p6 B=FE_OFN16_register_8__9 CI=p15 S=n381 CO=n380
XU804 ADDFX2 $PINS A=p15 B=n322 CI=n317 S=n315 CO=n314
XU805 ADDFX2 $PINS A=p22 B=n316 CI=n311 S=n309 CO=n308
XU806 ADDFX2 $PINS A=FE_OFN88_register_8__15 B=n307 CI=n310 S=n305 CO=n304
XU807 XNOR2X1 $PINS A=FE_OFN87_register_8__16 B=FE_OFN5821_register_8__18
+ Y=n307
XU808 ADDFX2 $PINS A=n343 B=n346 CI=n341 S=n339 CO=n338
XU809 XNOR2X1 $PINS A=n33 B=a[19] Y=product[34]
XU810 OAI21XL $PINS A0=n109 A1=n586 B0=n35 Y=n33
XU811 ADDFX2 $PINS A=a[14] B=FE_OFN6_register_8__12 CI=a[16] S=n329 CO=n328
XU812 ADDFX2 $PINS A=FE_OFN16_register_8__9 B=n356 CI=n349 S=n347 CO=n346
XU813 ADDFX2 $PINS A=p11 B=FE_OFN75_register_8__18 CI=n348 S=n341 CO=n340
XU814 ADDFX2 $PINS A=FE_OFN5821_register_8__18 B=a[13]
+ CI=FE_OFN87_register_8__16 S=n317 CO=n316
XU816 ADDFX2 $PINS A=p18 B=FE_OFN40_register_8__19 CI=n306 S=n301 CO=n300
XU817 OR2X2 $PINS A=FE_OFN87_register_8__16 B=FE_OFN5821_register_8__18 Y=n306
XU818 XNOR2X1 $PINS A=a[19] B=FE_OFN5821_register_8__18 Y=n299
XU819 OR2X2 $PINS A=a[19] B=FE_OFN5821_register_8__18 Y=n298
XU484 OAI2BB1X1 $PINS A0N=n258 A1N=n588 B0=n256 Y=n254
XU771 AOI2BB1X1 $PINS A0N=n136 A1N=n144 B0=n590 Y=n589
XU823 INVX1 $PINS A=n589 Y=n135
XU824 INVX1 $PINS A=n137 Y=n590
XU826 OR2X2 $PINS A=p5 B=a[1] Y=n592
.ENDS

.SUBCKT CONV_DW_mult_uns_36_0_0 a[35] a[34] a[33] a[32] a[31] a[30] a[29] a[28]
+ a[27] a[26] a[25] a[24] a[23] a[22] a[21] a[20] a[19] a[18] a[17] a[16] a[15]
+ a[14] a[13] a[12] a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1]
+ a[0] b[13] b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1]
+ b[0] product[49] product[48] product[47] product[46] product[45] product[44]
+ product[43] product[42] product[41] product[40] product[39] product[38]
+ product[37] product[36] product[35] product[34] product[33] product[32]
+ product[31] product[30] product[29] product[28] product[27] product[26]
+ product[25] product[24] product[23] product[22] product[21] product[20]
+ product[19] product[18] product[17] product[16] product[15] product[14]
+ product[13] product[12] product[11] product[10] product[9] product[8]
+ product[7] product[6] product[5] product[4] product[3] product[2] product[1]
+ product[0] FE_OFN45_N1548 FE_DBTN1180_N1618
*.CONNECT product[34] a[21]
*.CONNECT product[35] a[21]
*.CONNECT n453 a[18]
*.CONNECT n462 a[9]
*.CONNECT n464 a[7]
*.CONNECT n467 a[4]
*.CONNECT n468 a[3]
*.CONNECT n470 a[1]
XFE_OFC2138_n230 INVX1 $PINS A=n230 Y=n228
XFE_OFC2120_n2 INVX2 $PINS A=n2 Y=FE_DBTN162_n2
XFE_OFC2000_r2257_DIFF_6 CLKBUFX8 $PINS A=a[6] Y=FE_OFN6028_r2257_DIFF_6
XFE_OFC1925_n5251 CLKBUFX8 $PINS A=a[11] Y=FE_OFN5952_n5251
XFE_OFC1850_n6745 INVX4 $PINS A=a[13] Y=FE_OFN187_n6745
XU126 XOR2X2 $PINS A=n138 B=n15 Y=product[24]
XU127 AOI21X1 $PINS A0=n1 A1=n130 B0=FE_DBTN162_n2 Y=n129
XU131 AOI21X4 $PINS A0=n147 A1=n134 B0=n135 Y=n2
XU146 NOR2X2 $PINS A=n301 B=n296 Y=n141
XU148 XOR2X2 $PINS A=n154 B=n17 Y=product[22]
XU155 OAI21X2 $PINS A0=n152 A1=n158 B0=n153 Y=n147
XU158 NOR2X2 $PINS A=n302 B=n309 Y=n152
XU168 XOR2X1 $PINS A=n166 B=n19 Y=product[20]
XU172 NOR2X2 $PINS A=n164 B=n169 Y=n162
XU176 NOR2X2 $PINS A=n318 B=n327 Y=n164
XU195 OAI21X2 $PINS A0=n180 A1=n186 B0=n181 Y=n175
XU198 NOR2X2 $PINS A=n338 B=n347 Y=n180
XU210 AOI21X2 $PINS A0=n197 A1=n189 B0=n190 Y=n188
XU215 NOR2X1 $PINS A=n578 B=n367 Y=n191
XU221 NOR2X4 $PINS A=n368 B=n377 Y=n194
XU225 OAI21X2 $PINS A0=n210 A1=n198 B0=n199 Y=n197
XU242 XNOR2X2 $PINS A=n215 B=n27 Y=product[12]
XU244 AOI21X4 $PINS A0=n219 A1=n211 B0=n212 Y=n210
XU255 NOR2X2 $PINS A=n406 B=n413 Y=n216
XU259 OAI21X4 $PINS A0=n232 A1=n220 B0=n221 Y=n219
XU261 AOI21X2 $PINS A0=n579 A1=n228 B0=n223 Y=n221
XU276 XNOR2X2 $PINS A=n237 B=n31 Y=product[8]
XU278 AOI21X4 $PINS A0=n240 A1=n233 B0=n234 Y=n232
XU416 ADDFX2 $PINS A=a[19] B=n284 CI=n287 S=n282 CO=n281
XU417 NAND2X1 $PINS A=n5 B=n605 Y=n88
XU418 XOR2X1 $PINS A=n85 B=n597 Y=product[29]
XU419 AOI21X1 $PINS A0=n607 A1=n117 B0=n106 Y=n104
XU420 NAND2BXL $PINS AN=n136 B=n137 Y=n15
XU421 NOR2X2 $PINS A=n141 B=n136 Y=n134
XU422 ADDFX2 $PINS A=n345 B=a[16] CI=n336 S=n334 CO=n333
XU423 ADDFX2 $PINS A=a[5] B=FE_OFN5952_n5251 CI=a[8] S=n346 CO=n345
XU424 NAND2X1 $PINS A=n162 B=n174 Y=n160
XU425 ADDFHX1 $PINS A=n432 B=n467 CI=n243 S=product[4] CO=n242
XU426 ADDFHX2 $PINS A=n352 B=n359 CI=n350 S=n348 CO=n347
XU427 NAND2X1 $PINS A=a[14] B=n363 Y=n563
XU429 NOR2BX1 $PINS AN=n174 B=n169 Y=n167
XU430 NAND2X1 $PINS A=FE_DBTN162_n2 B=n5 Y=n548
XU431 NAND2X1 $PINS A=n548 B=n100 Y=n98
XU435 INVX1 $PINS A=n4 Y=n100
XU436 AOI21X2 $PINS A0=n97 A1=n1 B0=n98 Y=n96
XU437 OR2X2 $PINS A=n160 B=n188 Y=n549
XU438 NAND2X4 $PINS A=n549 B=n161 Y=n1
XU439 AOI21X2 $PINS A0=n162 A1=n175 B0=n163 Y=n161
XU441 AND2X1 $PINS A=n62 B=n1 Y=n550
XU442 NOR2X1 $PINS A=n550 B=n63 Y=n61
XU443 NOR2X1 $PINS A=n3 B=n64 Y=n62
XU444 OAI21XL $PINS A0=n2 A1=n64 B0=n65 Y=n63
XU445 OR2X2 $PINS A=n61 B=n565 Y=n567
XU446 NAND2X1 $PINS A=n231 B=n604 Y=n551
XU448 AND2X2 $PINS A=n551 B=n230 Y=n226
XU451 OAI21XL $PINS A0=n177 A1=n169 B0=n172 Y=n168
XU452 OAI21XL $PINS A0=n172 A1=n164 B0=n165 Y=n163
XU453 AOI21X1 $PINS A0=n4 A1=n77 B0=n555 Y=n76
XU454 AOI21X2 $PINS A0=n600 A1=n206 B0=n201 Y=n199
XU455 XNOR2X1 $PINS A=n231 B=n595 Y=product[9]
XU456 ADDFHX1 $PINS A=FE_OFN6028_r2257_DIFF_6 B=n462 CI=a[12] S=n336 CO=n335
XU457 XOR2X2 $PINS A=n145 B=n16 Y=product[23]
XU458 AOI21X1 $PINS A0=n73 A1=n1 B0=n74 Y=n72
XU459 NOR2XL $PINS A=n3 B=n75 Y=n73
XU460 NAND2X1 $PINS A=n318 B=n327 Y=n165
XU461 NAND2X1 $PINS A=n606 B=n605 Y=n79
XU462 NAND2X1 $PINS A=n422 B=n427 Y=n230
XU463 ADDFHX1 $PINS A=a[9] B=n429 CI=n424 S=n422 CO=n421
XU464 ADDFX2 $PINS A=n462 B=a[12] CI=n409 S=n400 CO=n399
XU465 ADDFX2 $PINS A=n385 B=a[12] CI=a[10] S=n374 CO=n373
XU466 ADDFX2 $PINS A=a[9] B=a[12] CI=a[17] S=n308 CO=n307
XU468 ADDFX2 $PINS A=n464 B=a[5] CI=n432 S=n430 CO=n429
XU469 XOR3X2 $PINS A=a[3] B=n470 C=n449 Y=n432
XU470 INVX2 $PINS A=n208 Y=n206
XU471 NOR2X2 $PINS A=n428 B=n433 Y=n235
XU472 ADDFX2 $PINS A=a[8] B=n435 CI=n430 S=n428 CO=n427
XU473 XOR2X1 $PINS A=n72 B=n9 Y=product[30]
XU475 OAI21X1 $PINS A0=n213 A1=n217 B0=n214 Y=n212
XU476 ADDFX2 $PINS A=n412 B=n417 CI=a[10] S=n408 CO=n407
XU477 ADDFX2 $PINS A=n470 B=n449 CI=FE_OFN6028_r2257_DIFF_6 S=n442 CO=n441
XU478 NOR2X1 $PINS A=n191 B=n194 Y=n189
XU479 ADDFX2 $PINS A=a[2] B=FE_OFN6028_r2257_DIFF_6 CI=n467 S=n426 CO=n425
XU480 ADDFHX2 $PINS A=n394 B=n401 CI=FE_OFN187_n6745 S=n390 CO=n389
XU482 INVX1 $PINS A=n119 Y=n117
XU483 INVX1 $PINS A=n203 Y=n201
XU484 OAI21X1 $PINS A0=n235 A1=n239 B0=n236 Y=n234
XU485 OAI21XL $PINS A0=n80 A1=n68 B0=n71 Y=n67
XU487 XOR3X2 $PINS A=n362 B=n369 C=n360 Y=n578
XU488 ADDFX2 $PINS A=a[3] B=a[5] CI=n442 S=n440 CO=n439
XU489 ADDFX2 $PINS A=n467 B=a[7] CI=a[12] S=n356 CO=n355
XU490 ADDFX2 $PINS A=n364 B=a[15] CI=n371 S=n360 CO=n359
XU491 ADDFX2 $PINS A=n453 B=n323 CI=n314 S=n312 CO=n311
XU492 NAND2X1 $PINS A=n470 B=a[3] Y=n560
XU495 OR2X2 $PINS A=n279 B=n278 Y=n605
XU496 NAND2X1 $PINS A=n566 B=n567 Y=product[31]
XU497 NAND2X1 $PINS A=n61 B=n565 Y=n566
XU498 INVX1 $PINS A=n3 Y=n130
XU499 NAND2X2 $PINS A=n600 B=n601 Y=n198
XU500 OAI21X1 $PINS A0=n191 A1=n195 B0=n192 Y=n190
XU501 OAI21X1 $PINS A0=n136 A1=n144 B0=n137 Y=n135
XU502 XOR2X1 $PINS A=n328 B=n337 Y=n592
XU503 XNOR2X1 $PINS A=n302 B=n309 Y=n17
XU504 NOR2BX1 $PINS AN=n60 B=n59 Y=n565
XU505 AOI21X1 $PINS A0=n187 A1=n167 B0=n168 Y=n166
XU506 NAND2BX1 $PINS AN=n191 B=n192 Y=n23
XU507 XNOR2X1 $PINS A=n318 B=n327 Y=n19
XU508 XOR2X2 $PINS A=n13 B=n120 Y=product[26]
XU509 NAND2X1 $PINS A=n579 B=n604 Y=n220
XU510 NOR2XL $PINS A=n3 B=n112 Y=n110
XU511 OAI2BB1X1 $PINS A0N=n240 A1N=n554 B0=n239 Y=n237
XU512 INVX1 $PINS A=n238 Y=n554
XU513 AOI21X2 $PINS A0=n1 A1=n146 B0=n147 Y=n145
XU514 NOR2X1 $PINS A=n213 B=n216 Y=n211
XU515 NOR2BX1 $PINS AN=n57 B=n79 Y=n53
XU516 NAND2BX1 $PINS AN=n238 B=n239 Y=n32
XU517 NAND2BX1 $PINS AN=n141 B=n144 Y=n16
XU518 NAND2X1 $PINS A=n601 B=n208 Y=n26
XU519 NOR2X1 $PINS A=n434 B=n439 Y=n238
XU520 AOI21X1 $PINS A0=n4 A1=n605 B0=n93 Y=n89
XU521 INVX1 $PINS A=n95 Y=n93
XU522 OAI2BB1X2 $PINS A0N=n187 A1N=n263 B0=n186 Y=n575
XU523 INVX1 $PINS A=n185 Y=n263
XU524 OAI2BB1X1 $PINS A0N=n606 A1N=n93 B0=n84 Y=n555
XU525 INVX1 $PINS A=n555 Y=n80
XU526 NAND2X1 $PINS A=n302 B=n309 Y=n153
XU527 NAND2BX1 $PINS AN=n216 B=n217 Y=n596
XU528 AOI21X1 $PINS A0=n209 A1=n601 B0=n206 Y=n204
XU529 AOI221X1 $PINS A0=n4 A1=n53 B0=n555 B1=n57 C0=n58 Y=n52
XU531 XNOR2X1 $PINS A=n428 B=n433 Y=n31
XU532 XOR2X1 $PINS A=n338 B=n347 Y=n576
XU533 NOR2X1 $PINS A=n235 B=n238 Y=n233
XU534 NAND2BX1 $PINS AN=n194 B=n195 Y=n593
XU535 OR2X2 $PINS A=n276 B=n277 Y=n606
XU536 OAI221XL $PINS A0=n557 A1=n124 B0=n2 B1=n112 C0=n119 Y=n111
XU537 INVX1 $PINS A=n602 Y=n557
XU538 AND2X2 $PINS A=n186 B=n263 Y=n591
XU539 OAI2BB1X1 $PINS A0N=n147 A1N=n558 B0=n144 Y=n140
XU540 INVX1 $PINS A=n141 Y=n558
XU541 NOR2BX1 $PINS AN=n5 B=n3 Y=n97
XU542 ADDFHX2 $PINS A=n420 B=a[7] CI=a[5] S=n418 CO=n417
XU543 CLKINVX3 $PINS A=n197 Y=n196
XU544 ADDFX2 $PINS A=a[19] B=n308 CI=n313 S=n304 CO=n303
XU545 ADDFX2 $PINS A=a[14] B=n325 CI=n316 S=n314 CO=n313
XU547 ADDFHX2 $PINS A=n306 B=n311 CI=n304 S=n302 CO=n301
XU548 ADDFX2 $PINS A=n315 B=a[15] CI=a[20] S=n306 CO=n305
XU549 NAND2X2 $PINS A=n146 B=n134 Y=n3
XU550 ADDFX2 $PINS A=n392 B=n399 CI=n390 S=n388 CO=n387
XU551 ADDFHX2 $PINS A=n444 B=n431 CI=n242 S=product[5] CO=n241
XU552 ADDFHX2 $PINS A=n335 B=a[17] CI=a[20] S=n324 CO=n323
XU554 ADDFHX1 $PINS A=a[15] B=n344 CI=n351 S=n340 CO=n339
XU555 NAND3X1 $PINS A=n564 B=n562 C=n563 Y=n351
XU556 ADDFX2 $PINS A=n346 B=FE_OFN187_n6745 CI=n355 S=n344 CO=n343
XU557 ADDFHX1 $PINS A=a[7] B=a[10] CI=FE_OFN187_n6745 S=n326 CO=n325
XU558 ADDFX2 $PINS A=FE_OFN187_n6745 B=a[16] CI=n373 S=n362 CO=n361
XU559 NAND2X1 $PINS A=n414 B=n421 Y=n225
XU560 XNOR2X1 $PINS A=n209 B=n26 Y=product[13]
XU561 NOR2X2 $PINS A=n398 B=n405 Y=n213
XU562 ADDFX2 $PINS A=n410 B=n415 CI=n408 S=n406 CO=n405
XU563 ADDFHX1 $PINS A=n402 B=n407 CI=n400 S=n398 CO=n397
XU564 AND2X1 $PINS A=n574 B=n246 Y=product[1]
XU565 INVX1 $PINS A=n246 Y=n247
XU566 ADDFX2 $PINS A=a[10] B=a[16] CI=FE_OFN187_n6745 S=n300 CO=n299
XU567 ADDFX2 $PINS A=n365 B=a[10] CI=a[16] S=n354 CO=n353
XU569 ADDFX2 $PINS A=n453 B=a[15] CI=a[20] S=n278 CO=n277
XU571 AOI21X2 $PINS A0=n187 A1=n174 B0=n175 Y=n173
XU572 NAND2X1 $PINS A=n449 B=a[3] Y=n559
XU573 ADDFHX2 $PINS A=n247 B=n470 CI=a[2] S=product[2] CO=n244
XU574 NAND2X1 $PINS A=n470 B=n449 Y=n561
XU575 NAND3X1 $PINS A=n561 B=n559 C=n560 Y=n431
XU576 XOR3X2 $PINS A=n363 B=a[14] C=n356 Y=n352
XU577 NAND2X1 $PINS A=n356 B=n363 Y=n562
XU578 NAND2X1 $PINS A=a[14] B=n356 Y=n564
XU579 ADDFX2 $PINS A=n462 B=n375 CI=n366 S=n364 CO=n363
XU581 NOR2X1 $PINS A=n295 B=n290 Y=n136
XU582 INVX1 $PINS A=n175 Y=n177
XU583 NAND2X1 $PINS A=n358 B=n367 Y=n192
XU584 NOR2X1 $PINS A=n157 B=n152 Y=n146
XU585 XNOR2X4 $PINS A=n193 B=n23 Y=product[16]
XU586 XOR2X2 $PINS A=n109 B=n12 Y=product[27]
XU587 OAI21X2 $PINS A0=n196 A1=n194 B0=n195 Y=n193
XU588 ADDFX2 $PINS A=n470 B=n573 CI=n467 S=n386 CO=n385
XU589 INVX1 $PINS A=n225 Y=n223
XU591 ADDFX2 $PINS A=n431 B=a[8] CI=n426 S=n424 CO=n423
XU592 ADDFX2 $PINS A=a[12] B=a[15] CI=n453 S=n288 CO=n287
XU593 ADDFX2 $PINS A=n453 B=n300 CI=n307 S=n298 CO=n297
XU594 NAND2X2 $PINS A=n368 B=n377 Y=n195
XU595 ADDFX2 $PINS A=a[17] B=n354 CI=n361 S=n350 CO=n349
XU596 ADDFX2 $PINS A=n362 B=n369 CI=n360 S=n358 CO=n357
XU597 ADDFHX2 $PINS A=a[19] B=n324 CI=n331 S=n320 CO=n319
XU598 ADDFX2 $PINS A=a[15] B=n326 CI=n333 S=n322 CO=n321
XU599 ADDFX2 $PINS A=n305 B=n298 CI=n303 S=n296 CO=n295
XU600 ADDFX2 $PINS A=n450 B=n467 CI=a[5] S=n444 CO=n443
XU601 NAND2X1 $PINS A=n388 B=n397 Y=n208
XU602 OR2X2 $PINS A=n388 B=n397 Y=n601
XU603 NAND2X1 $PINS A=n295 B=n290 Y=n137
XU606 NAND2X1 $PINS A=n259 B=n158 Y=n18
XU607 AND2X2 $PINS A=n255 B=n124 Y=n599
XU609 ADDFHX1 $PINS A=n334 B=a[19] CI=n341 S=n330 CO=n329
XU610 ADDFX2 $PINS A=a[14] B=n453 CI=n343 S=n332 CO=n331
XU611 ADDFX2 $PINS A=a[7] B=FE_OFN5952_n5251 CI=n386 S=n384 CO=n383
XU612 ADDFX2 $PINS A=a[7] B=n441 CI=n436 S=n434 CO=n433
XU613 NAND2X1 $PINS A=n600 B=n203 Y=n25
XU614 ADDFX2 $PINS A=FE_OFN6028_r2257_DIFF_6 B=n420 CI=a[8] S=n394 CO=n393
XU615 NOR2X1 $PINS A=n3 B=n123 Y=n121
XU616 ADDFHX2 $PINS A=n321 B=n319 CI=n312 S=n310 CO=n309
XU617 ADDFHX1 $PINS A=a[17] B=n353 CI=n453 S=n342 CO=n341
XU618 ADDFX2 $PINS A=FE_OFN6028_r2257_DIFF_6 B=a[3] CI=FE_OFN5952_n5251 S=n366
+ CO=n365
XU619 XOR2X2 $PINS A=n204 B=n25 Y=product[14]
XU620 NAND2X1 $PINS A=n348 B=n357 Y=n186
XU621 ADDFX2 $PINS A=n411 B=FE_OFN5952_n5251 CI=n404 S=n402 CO=n401
XU622 ADDFHX1 $PINS A=a[2] B=a[5] CI=a[8] S=n376 CO=n375
XU623 NAND2X1 $PINS A=n328 B=n337 Y=n172
XU624 NOR2X2 $PINS A=n328 B=n337 Y=n169
XU625 ADDFHX2 $PINS A=n332 B=n339 CI=n330 S=n328 CO=n327
XU626 NAND2X1 $PINS A=n338 B=n347 Y=n181
XU627 ADDFX2 $PINS A=n349 B=n342 CI=n340 S=n338 CO=n337
XU628 ADDFX2 $PINS A=n450 B=FE_OFN6028_r2257_DIFF_6 CI=n467 S=n436 CO=n435
XU629 NOR2X1 $PINS A=n289 B=n286 Y=n123
XU630 ADDFX2 $PINS A=n293 B=n288 CI=n291 S=n286 CO=n285
XU631 NAND2X1 $PINS A=n285 B=n282 Y=n119
XU632 AOI21XL $PINS A0=n4 A1=n40 B0=n41 Y=n39
XU633 AOI21XL $PINS A0=n4 A1=n66 B0=n67 Y=n65
XU634 NOR2X1 $PINS A=n348 B=n357 Y=n185
XU635 ADDFX2 $PINS A=a[14] B=a[17] CI=n283 S=n280 CO=n279
XU636 NOR2X1 $PINS A=n275 B=a[17] Y=n68
XU637 ADDFHX1 $PINS A=a[2] B=a[7] CI=a[5] S=n404 CO=n403
XU638 ADDFHX2 $PINS A=n376 B=n383 CI=n374 S=n372 CO=n371
XU639 ADDFHX2 $PINS A=n379 B=n372 CI=n370 S=n368 CO=n367
XU640 ADDFX2 $PINS A=a[8] B=FE_OFN5952_n5251 CI=a[16] S=n316 CO=n315
XU641 ADDFHX2 $PINS A=n382 B=n389 CI=n380 S=n378 CO=n377
XU643 ADDFX2 $PINS A=FE_OFN5952_n5251 B=a[14] CI=a[17] S=n294 CO=n293
XU644 NAND2X1 $PINS A=n398 B=n405 Y=n214
XU645 NAND2X1 $PINS A=n434 B=n439 Y=n239
XU646 ADDFX2 $PINS A=n294 B=n297 CI=n292 S=n290 CO=n289
XU647 INVX1 $PINS A=n157 Y=n259
XU648 NAND2X1 $PINS A=n604 B=n230 Y=n595
XU649 OR2X2 $PINS A=n281 B=n280 Y=n607
XU650 NAND2X1 $PINS A=n255 B=n602 Y=n112
XU651 NAND2X1 $PINS A=n289 B=n286 Y=n124
XU652 NOR2X1 $PINS A=n3 B=n88 Y=n86
XU653 XOR2X1 $PINS A=n96 B=n598 Y=product[28]
XU654 INVX1 $PINS A=n35 Y=product[33]
XU655 INVX1 $PINS A=n232 Y=n231
XU656 AND2X2 $PINS A=FE_DBTN1180_N1618 B=n468 Y=n573
XU657 OR2X2 $PINS A=n470 B=FE_DBTN1180_N1618 Y=n574
XU658 ADDFX2 $PINS A=a[3] B=n450 CI=n244 S=product[3] CO=n243
XU659 XOR2X2 $PINS A=n575 B=n576 Y=product[18]
XU660 INVX2 $PINS A=n210 Y=n209
XU661 XOR2X2 $PINS A=n187 B=n591 Y=product[17]
XU662 NAND2X1 $PINS A=n470 B=FE_DBTN1180_N1618 Y=n246
XU663 ADDFX2 $PINS A=a[16] B=FE_OFN187_n6745 CI=a[20] S=n284 CO=n283
XU664 OR2X2 $PINS A=n414 B=n421 Y=n579
XU665 ADDFX2 $PINS A=n470 B=FE_OFN6028_r2257_DIFF_6 CI=n573 S=n412 CO=n411
XU666 XNOR2X2 $PINS A=n173 B=n592 Y=product[19]
XU667 OR2X2 $PINS A=n285 B=n282 Y=n602
XU668 ADDFX2 $PINS A=n467 B=FE_OFN5952_n5251 CI=a[8] S=n410 CO=n409
XU669 AOI21X1 $PINS A0=n86 A1=n1 B0=n87 Y=n85
XU670 ADDFHX2 $PINS A=a[14] B=n381 CI=a[15] S=n370 CO=n369
XU671 NAND2BX1 $PINS AN=n213 B=n214 Y=n27
XU672 ADDFX2 $PINS A=a[16] B=a[20] CI=a[19] S=n276 CO=n275
XU673 NAND2X1 $PINS A=n57 B=n608 Y=n42
XU674 OAI21XL $PINS A0=n2 A1=n88 B0=n89 Y=n87
XU676 XNOR2X1 $PINS A=n240 B=n32 Y=product[7]
XU677 NOR2BX1 $PINS AN=n146 B=n141 Y=n139
XU678 XNOR2X4 $PINS A=n1 B=n18 Y=product[21]
XU679 AOI21X1 $PINS A0=n1 A1=n139 B0=n140 Y=n138
XU680 NAND2X1 $PINS A=n602 B=n607 Y=n103
XU681 OAI21XL $PINS A0=n2 A1=n75 B0=n76 Y=n74
XU682 NAND2X1 $PINS A=n579 B=n225 Y=n594
XU683 XOR2X1 $PINS A=n218 B=n596 Y=product[11]
XU684 OAI21X1 $PINS A0=n218 A1=n216 B0=n217 Y=n215
XU685 ADDFHX2 $PINS A=a[10] B=n423 CI=n416 S=n414 CO=n413
XU686 ADDHX4 $PINS A=FE_DBTN1180_N1618 B=a[2] S=n450 CO=n449
XU687 ADDFHX2 $PINS A=n440 B=n443 CI=n241 S=product[6] CO=n240
XU688 AOI21X1 $PINS A0=n110 A1=n1 B0=n111 Y=n109
XU689 AOI21X1 $PINS A0=n121 A1=n1 B0=n122 Y=n120
XU690 OAI21XL $PINS A0=n2 A1=n123 B0=n124 Y=n122
XU691 AOI21X2 $PINS A0=n1 A1=n259 B0=n156 Y=n154
XU692 CLKINVX3 $PINS A=n219 Y=n218
XU693 XOR2X1 $PINS A=FE_DBTN1180_N1618 B=n468 Y=n420
XU694 XOR2X2 $PINS A=n196 B=n593 Y=product[15]
XU695 XOR2X4 $PINS A=n226 B=n594 Y=product[10]
XU696 ADDFHX2 $PINS A=n462 B=n393 CI=n384 S=n382 CO=n381
XU697 OAI21X1 $PINS A0=n103 A1=n124 B0=n104 Y=n4
XU698 INVX1 $PINS A=n108 Y=n106
XU699 NAND2XL $PINS A=n606 B=n84 Y=n597
XU700 INVX4 $PINS A=n188 Y=n187
XU701 NAND2XL $PINS A=n5 B=n53 Y=n51
XU703 NOR2X2 $PINS A=n185 B=n180 Y=n174
XU704 NOR2X1 $PINS A=n103 B=n123 Y=n5
XU705 NAND2X1 $PINS A=n310 B=n317 Y=n158
XU706 NOR2X1 $PINS A=n310 B=n317 Y=n157
XU707 NAND2XL $PINS A=n605 B=n95 Y=n598
XU708 ADDFHX2 $PINS A=n322 B=n329 CI=n320 S=n318 CO=n317
XU709 NAND2BXL $PINS AN=n68 B=n71 Y=n9
XU710 NAND2XL $PINS A=n281 B=n280 Y=n108
XU712 AOI21XL $PINS A0=n58 A1=n608 B0=n45 Y=n43
XU713 ADDFX2 $PINS A=a[20] B=n299 CI=a[19] S=n292 CO=n291
XU714 ADDFX2 $PINS A=n403 B=a[12] CI=a[10] S=n392 CO=n391
XU715 NAND2X1 $PINS A=n5 B=n77 Y=n75
XU716 INVX1 $PINS A=n123 Y=n255
XU717 XNOR2X2 $PINS A=n129 B=n599 Y=product[25]
XU718 NAND2XL $PINS A=n5 B=n40 Y=n38
XU719 INVX1 $PINS A=n79 Y=n77
XU720 INVX1 $PINS A=n158 Y=n156
XU721 NAND2X1 $PINS A=n301 B=n296 Y=n144
XU722 OR2X4 $PINS A=n378 B=n387 Y=n600
XU723 NAND2X1 $PINS A=n378 B=n387 Y=n203
XU724 NAND2X1 $PINS A=n602 B=n119 Y=n13
XU725 NAND2X1 $PINS A=n607 B=n108 Y=n12
XU726 NOR2XL $PINS A=n42 B=n79 Y=n40
XU727 NAND2XL $PINS A=n5 B=n66 Y=n64
XU728 OAI21XL $PINS A0=n2 A1=n51 B0=n52 Y=n50
XU729 AOI21XL $PINS A0=n36 A1=n1 B0=n37 Y=n35
XU730 NOR2XL $PINS A=n3 B=n38 Y=n36
XU731 OAI21XL $PINS A0=n2 A1=n38 B0=n39 Y=n37
XU732 NAND2X1 $PINS A=n406 B=n413 Y=n217
XU734 NAND2X1 $PINS A=n428 B=n433 Y=n236
XU735 OR2X2 $PINS A=n422 B=n427 Y=n604
XU736 OAI21XL $PINS A0=n71 A1=n59 B0=n60 Y=n58
XU737 NOR2X1 $PINS A=n79 B=n68 Y=n66
XU738 NOR2X1 $PINS A=n68 B=n59 Y=n57
XU739 OAI21XL $PINS A0=n42 A1=n80 B0=n43 Y=n41
XU740 INVX1 $PINS A=n47 Y=n45
XU741 NAND2X1 $PINS A=n279 B=n278 Y=n95
XU742 NAND2X1 $PINS A=n276 B=n277 Y=n84
XU743 AOI21XL $PINS A0=n49 A1=n1 B0=n50 Y=n48
XU744 NOR2XL $PINS A=n3 B=n51 Y=n49
XU745 ADDFHX1 $PINS A=n425 B=n418 CI=n462 S=n416 CO=n415
XU746 ADDFHX1 $PINS A=FE_OFN187_n6745 B=n391 CI=a[14] S=n380 CO=n379
XU747 NOR2XL $PINS A=n453 B=a[20] Y=n59
XU748 NAND2XL $PINS A=n275 B=a[17] Y=n71
XU749 NAND2XL $PINS A=n453 B=a[35] Y=n60
XU750 OR2XL $PINS A=a[19] B=a[34] Y=n608
XU751 NAND2XL $PINS A=a[19] B=a[33] Y=n47
XU605 XNOR2X1 $PINS A=n48 B=n624 Y=product[32]
XU711 AND2X2 $PINS A=n608 B=n47 Y=n624
.ENDS

.SUBCKT CONV_DW01_add_16 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XFE_RC_508_0 AOI21X2 $PINS A0=n79 A1=n85 B0=n80 Y=n78
XFE_OCPC2265_n1 BUFX3 $PINS A=n1 Y=FE_OCPN6177_n1
XFE_OCPC2264_n76 BUFX8 $PINS A=n76 Y=FE_OCPN6176_n76
XFE_RC_498_0 OR2X4 $PINS A=n88 B=n77 Y=FE_RN_277_0
XFE_RC_497_0 NAND2X4 $PINS A=n78 B=FE_RN_277_0 Y=n76
XFE_OFC2068_n51 CLKINVX3 $PINS A=n51 Y=n49
XFE_OFC2063_n89 INVX2 $PINS A=n88 Y=FE_OFN6066_n89
XFE_OFC2062_n89 BUFX8 $PINS A=n89 Y=n88
XFE_OFC2060_n50 CLKINVX3 $PINS A=n50 Y=n48
XFE_OFC1936_N1472 BUFX3 $PINS A=A[17] Y=FE_OFN5963_N1472
XFE_OFC1932_N1385 BUFX8 $PINS A=B[35] Y=FE_OFN5959_N1385
XFE_OFC1927_N1473 BUFX3 $PINS A=A[18] Y=FE_OFN5954_N1473
XFE_OFC1920_N1367 CLKBUFX8 $PINS A=B[17] Y=FE_OFN5947_N1367
XFE_OFC1909_n5321 INVX1 $PINS A=A[0] Y=FE_OFN5938_n5321
XFE_OFC1413_n111 INVX1 $PINS A=n111 Y=n110
XFE_OFC859_n76 INVX8 $PINS A=n76 Y=n75
XFE_OFC201_n398 INVX1 $PINS A=n398 Y=n7
XU6 XNOR2X4 $PINS A=n47 B=n3 Y=SUM[34]
XU12 NAND2X2 $PINS A=n371 B=n46 Y=n3
XU21 OAI21X2 $PINS A0=n52 A1=n56 B0=n53 Y=n51
XU24 NOR2X4 $PINS A=A[33] B=B[33] Y=n52
XU26 XOR2X4 $PINS A=n374 B=n5 Y=SUM[32]
XU27 OAI21X4 $PINS A0=n1 A1=n55 B0=n56 Y=n54
XU30 NOR2X4 $PINS A=B[32] B=A[32] Y=n55
XU31 NAND2X2 $PINS A=B[32] B=A[32] Y=n56
XU33 AOI21X4 $PINS A0=FE_OCPN6176_n76 A1=n57 B0=n58 Y=n1
XU35 OAI21X4 $PINS A0=n59 A1=n63 B0=n60 Y=n58
XU38 NOR2X4 $PINS A=B[31] B=A[31] Y=n59
XU40 XNOR2X4 $PINS A=n68 B=n7 Y=SUM[30]
XU41 OAI21X4 $PINS A0=n75 A1=n62 B0=n63 Y=n61
XU48 NOR2X4 $PINS A=B[30] B=A[30] Y=n66
XU59 NAND2X4 $PINS A=B[29] B=A[29] Y=n70
XU63 NAND2X2 $PINS A=n79 B=n372 Y=n77
XU69 NOR2X4 $PINS A=B[28] B=A[28] Y=n81
XU79 XNOR2X1 $PINS A=n94 B=n11 Y=SUM[26]
XU81 AOI21X2 $PINS A0=n98 A1=n90 B0=n91 Y=n89
XU83 OAI21X2 $PINS A0=n92 A1=n96 B0=n93 Y=n91
XU86 NOR2X4 $PINS A=A[26] B=B[26] Y=n92
XU92 NOR2X4 $PINS A=B[25] B=A[25] Y=n95
XU93 NAND2X4 $PINS A=B[25] B=A[25] Y=n96
XU96 OAI21X4 $PINS A0=n111 A1=n99 B0=n100 Y=n98
XU98 AOI21X2 $PINS A0=n383 A1=n107 B0=n102 Y=n100
XU112 NAND2X2 $PINS A=B[23] B=A[23] Y=n109
XU113 XNOR2X1 $PINS A=n116 B=n15 Y=SUM[22]
XU115 AOI21X4 $PINS A0=n112 A1=n120 B0=n113 Y=n111
XU116 NOR2X2 $PINS A=n114 B=n117 Y=n112
XU117 OAI21X2 $PINS A0=n114 A1=n118 B0=n115 Y=n113
XU120 NOR2X4 $PINS A=B[22] B=A[22] Y=n114
XU126 NOR2X2 $PINS A=B[21] B=A[21] Y=n117
XU130 OAI21X4 $PINS A0=n133 A1=n121 B0=n122 Y=n120
XU175 NOR2X4 $PINS A=B[15] B=A[15] Y=n148
XU181 NOR2X2 $PINS A=A[14] B=B[14] Y=n151
XU182 NAND2X2 $PINS A=B[14] B=A[14] Y=n152
XU185 OAI21X4 $PINS A0=n157 A1=n155 B0=n156 Y=n154
XU191 AOI21X4 $PINS A0=n158 A1=n166 B0=n159 Y=n157
XU293 NAND2X2 $PINS A=B[27] B=A[27] Y=n87
XU294 INVX1 $PINS A=n179 Y=n178
XU295 XNOR2X2 $PINS A=n138 B=n19 Y=SUM[18]
XU296 INVX4 $PINS A=n70 Y=n72
XU297 NAND2X1 $PINS A=n153 B=n368 Y=n369
XU298 NAND2X1 $PINS A=n154 B=n23 Y=n370
XU299 NAND2X1 $PINS A=n369 B=n370 Y=SUM[14]
XU301 INVX1 $PINS A=n23 Y=n368
XU302 INVX1 $PINS A=n154 Y=n153
XU303 NAND2BX1 $PINS AN=n155 B=n156 Y=n24
XU304 NAND2X1 $PINS A=B[13] B=A[13] Y=n156
XU305 NOR2X2 $PINS A=B[11] B=A[11] Y=n163
XU306 CLKINVX3 $PINS A=n69 Y=n71
XU307 NOR2X4 $PINS A=B[29] B=A[29] Y=n69
XU308 INVX2 $PINS A=n142 Y=n376
XU309 NOR2X2 $PINS A=n136 B=n139 Y=n134
XU310 NAND2X2 $PINS A=B[31] B=A[31] Y=n60
XU311 NAND2X2 $PINS A=B[19] B=A[19] Y=n131
XU312 INVX1 $PINS A=n104 Y=n102
XU313 INVX1 $PINS A=n166 Y=n165
XU314 NAND2X2 $PINS A=B[11] B=A[11] Y=n164
XU315 OR2X2 $PINS A=A[9] B=B[9] Y=n387
XU316 XOR2X2 $PINS A=n376 B=n20 Y=SUM[17]
XU320 INVX1 $PINS A=n82 Y=n80
XU321 NAND2X1 $PINS A=n385 B=n387 Y=n167
XU322 NAND2BX1 $PINS AN=n92 B=n93 Y=n11
XU323 AOI21X4 $PINS A0=n134 A1=n142 B0=n135 Y=n133
XU324 NAND2BX1 $PINS AN=n163 B=n164 Y=n26
XU326 AOI21X2 $PINS A0=n129 A1=n384 B0=n124 Y=n122
XU327 INVX1 $PINS A=n126 Y=n124
XU328 AOI21XL $PINS A0=n178 A1=n387 B0=n175 Y=n173
XU329 NAND2BX2 $PINS AN=n55 B=n56 Y=n5
XU330 NOR2BX4 $PINS AN=n53 B=n52 Y=n388
XU331 OAI21X2 $PINS A0=n151 A1=n153 B0=n152 Y=n150
XU332 NAND2BXL $PINS AN=n160 B=n161 Y=n25
XU333 INVX1 $PINS A=n177 Y=n175
XU334 OAI21X1 $PINS A0=n119 A1=n117 B0=n118 Y=n116
XU335 AOI21X1 $PINS A0=n51 A1=n371 B0=n44 Y=n42
XU336 INVX1 $PINS A=n46 Y=n44
XU337 NAND2BXL $PINS AN=n139 B=n140 Y=n20
XU338 NAND2BX1 $PINS AN=n151 B=n152 Y=n23
XU339 NAND2XL $PINS A=n79 B=n82 Y=n378
XU340 NAND2BX1 $PINS AN=n114 B=n115 Y=n15
XU342 AOI21X4 $PINS A0=n64 A1=n72 B0=n65 Y=n63
XU343 NAND2BX1 $PINS AN=n193 B=n194 Y=n32
XU344 NAND2BX1 $PINS AN=n201 B=n202 Y=n34
XU345 NAND2BX1 $PINS AN=n117 B=n118 Y=n16
XU346 NAND2BX1 $PINS AN=n143 B=n144 Y=n21
XU347 NAND2BX1 $PINS AN=n136 B=n137 Y=n19
XU348 NAND2BX1 $PINS AN=n185 B=n186 Y=n30
XU349 AOI21X2 $PINS A0=FE_OFN6066_n89 A1=n372 B0=n85 Y=n83
XU350 INVX1 $PINS A=n87 Y=n85
XU351 NOR2BX1 $PINS AN=n216 B=n215 Y=SUM[0]
XU352 OAI21X4 $PINS A0=FE_OCPN6177_n1 A1=n48 B0=n49 Y=n47
XU353 OAI21X2 $PINS A0=n136 A1=n140 B0=n137 Y=n135
XU354 CLKINVX3 $PINS A=n120 Y=n119
XU355 NOR2X1 $PINS A=B[7] B=A[7] Y=n185
XU356 INVX1 $PINS A=n98 Y=n97
XU357 NAND2X1 $PINS A=B[18] B=FE_OFN5954_N1473 Y=n137
XU358 CLKINVX3 $PINS A=n67 Y=n65
XU359 NAND2X1 $PINS A=B[34] B=A[34] Y=n46
XU360 NAND2X2 $PINS A=B[21] B=A[21] Y=n118
XU361 NAND2X1 $PINS A=B[15] B=A[15] Y=n149
XU363 NOR2X1 $PINS A=n52 B=n55 Y=n50
XU364 AOI21X1 $PINS A0=n132 A1=n382 B0=n129 Y=n127
XU365 INVX1 $PINS A=n199 Y=n197
XU366 NAND2X2 $PINS A=B[30] B=A[30] Y=n67
XU367 AND2X2 $PINS A=n131 B=n382 Y=n377
XU368 NAND2X1 $PINS A=FE_OFN5959_N1385 B=A[35] Y=n39
XU369 OR2X2 $PINS A=FE_OFN5959_N1385 B=A[35] Y=n394
XU370 XNOR2X1 $PINS A=n110 B=n14 Y=SUM[23]
XU371 OR2X4 $PINS A=B[34] B=A[34] Y=n371
XU373 OR2X2 $PINS A=B[8] B=A[8] Y=n391
XU374 NAND2XL $PINS A=n385 B=n172 Y=n27
XU375 OAI21X2 $PINS A0=n97 A1=n95 B0=n96 Y=n94
XU377 INVX1 $PINS A=n133 Y=n132
XU378 NAND2X2 $PINS A=FE_OFN5947_N1367 B=FE_OFN5963_N1472 Y=n140
XU379 AOI21X1 $PINS A0=n391 A1=n184 B0=n181 Y=n179
XU380 AND2X2 $PINS A=n237 B=n149 Y=n381
XU381 NAND2X1 $PINS A=B[9] B=A[9] Y=n177
XU382 XOR2X4 $PINS A=n119 B=n16 Y=SUM[21]
XU383 OAI21X1 $PINS A0=n376 A1=n139 B0=n140 Y=n138
XU384 OAI2BB1X1 $PINS A0N=n397 A1N=n214 B0=n213 Y=n395
XU385 NOR2X2 $PINS A=B[13] B=A[13] Y=n155
XU386 INVX1 $PINS A=n191 Y=n189
XU387 NAND2X1 $PINS A=B[7] B=A[7] Y=n186
XU388 AOI21X1 $PINS A0=n396 A1=n395 B0=n205 Y=n203
XU389 INVX1 $PINS A=n207 Y=n205
XU390 XOR2X1 $PINS A=n132 B=n377 Y=SUM[19]
XU391 INVX1 $PINS A=n131 Y=n129
XU392 NAND2X1 $PINS A=B[24] B=A[24] Y=n104
XU393 CLKINVX3 $PINS A=n109 Y=n107
XU394 OR2X4 $PINS A=B[27] B=A[27] Y=n372
XU395 XOR2X1 $PINS A=n145 B=n21 Y=SUM[16]
XU396 NAND2XL $PINS A=n387 B=n177 Y=n28
XU397 NAND2X1 $PINS A=B[28] B=A[28] Y=n82
XU398 CLKINVX4 $PINS A=n81 Y=n79
XU399 AOI21X2 $PINS A0=n385 A1=n175 B0=n170 Y=n168
XU400 XOR2X2 $PINS A=FE_OFN6066_n89 B=n380 Y=SUM[27]
XU401 XOR2X1 $PINS A=n105 B=n13 Y=SUM[24]
XU402 INVX1 $PINS A=n172 Y=n170
XU404 OR2X2 $PINS A=B[31] B=A[31] Y=n373
XU405 OAI21XL $PINS A0=n187 A1=n185 B0=n186 Y=n184
XU406 NAND2XL $PINS A=n386 B=n109 Y=n14
XU407 AOI21X1 $PINS A0=n110 A1=n386 B0=n107 Y=n105
XU408 NOR2X2 $PINS A=n160 B=n163 Y=n158
XU409 OAI21X2 $PINS A0=n160 A1=n164 B0=n161 Y=n159
XU410 INVX1 $PINS A=n148 Y=n237
XU411 XNOR2XL $PINS A=n31 B=n192 Y=SUM[6]
XU412 OAI21XL $PINS A0=n193 A1=n195 B0=n194 Y=n192
XU413 OAI21XL $PINS A0=n165 A1=n163 B0=n164 Y=n162
XU414 OAI21XL $PINS A0=n201 A1=n203 B0=n202 Y=n200
XU415 NOR2X2 $PINS A=n148 B=n151 Y=n146
XU416 OAI21X2 $PINS A0=n148 A1=n152 B0=n149 Y=n147
XU417 NOR2X2 $PINS A=B[16] B=A[16] Y=n143
XU418 NOR2X2 $PINS A=FE_OFN5947_N1367 B=FE_OFN5963_N1472 Y=n139
XU419 AOI21X4 $PINS A0=FE_OCPN6176_n76 A1=n57 B0=n58 Y=n374
XU420 NOR2X2 $PINS A=n92 B=n95 Y=n90
XU421 NOR2X1 $PINS A=B[3] B=A[3] Y=n201
XU422 OR2X4 $PINS A=B[10] B=A[10] Y=n385
XU423 NOR2X2 $PINS A=FE_OFN5954_N1473 B=B[18] Y=n136
XU424 XNOR2X1 $PINS A=n162 B=n25 Y=SUM[12]
XU425 AOI21X1 $PINS A0=n390 A1=n192 B0=n189 Y=n187
XU426 AOI21X1 $PINS A0=n200 A1=n393 B0=n197 Y=n195
XU427 NAND2X1 $PINS A=B[12] B=A[12] Y=n161
XU428 AND2X2 $PINS A=n60 B=n373 Y=n389
XU429 NOR2X4 $PINS A=n59 B=n62 Y=n57
XU430 OAI21X4 $PINS A0=n145 A1=n143 B0=n144 Y=n142
XU431 NAND2X2 $PINS A=B[16] B=A[16] Y=n144
XU432 OAI21X2 $PINS A0=n167 A1=n179 B0=n168 Y=n166
XU433 NOR2X4 $PINS A=B[12] B=A[12] Y=n160
XU434 OR2X4 $PINS A=B[19] B=A[19] Y=n382
XU435 NAND2X2 $PINS A=n71 B=n70 Y=n379
XU436 NAND2X1 $PINS A=B[8] B=A[8] Y=n183
XU437 OR2X2 $PINS A=B[2] B=A[2] Y=n396
XU438 NAND2X2 $PINS A=n384 B=n382 Y=n121
XU439 NAND2X1 $PINS A=B[20] B=A[20] Y=n126
XU440 OR2X2 $PINS A=B[4] B=A[4] Y=n393
XU441 XOR2X1 $PINS A=n165 B=n26 Y=SUM[11]
XU442 AOI21X4 $PINS A0=n146 A1=n154 B0=n147 Y=n145
XU443 NAND2X2 $PINS A=n383 B=n386 Y=n99
XU444 INVX1 $PINS A=n216 Y=n214
XU445 NAND2XL $PINS A=n384 B=n126 Y=n17
XU446 NAND2BXL $PINS AN=n95 B=n96 Y=n12
XU447 XOR2X2 $PINS A=n83 B=n378 Y=SUM[28]
XU448 XOR2X4 $PINS A=n75 B=n379 Y=SUM[29]
XU449 NAND2XL $PINS A=n104 B=n383 Y=n13
XU450 NAND2X1 $PINS A=B[10] B=A[10] Y=n172
XU451 NAND2X4 $PINS A=n71 B=n64 Y=n62
XU452 NAND2XL $PINS A=n390 B=n191 Y=n31
XU453 NAND2XL $PINS A=n393 B=n199 Y=n33
XU454 NAND2XL $PINS A=B[3] B=A[3] Y=n202
XU455 XNOR2X1 $PINS A=n35 B=n395 Y=SUM[2]
XU456 NAND2XL $PINS A=n396 B=n207 Y=n35
XU457 NAND2XL $PINS A=B[1] B=A[1] Y=n213
XU458 NOR2XL $PINS A=B[0] B=FE_OFN5938_n5321 Y=n215
XU459 AND2X2 $PINS A=n372 B=n87 Y=n380
XU460 XOR2X2 $PINS A=n150 B=n381 Y=SUM[15]
XU461 XOR2X4 $PINS A=n127 B=n17 Y=SUM[20]
XU462 XNOR2X1 $PINS A=n28 B=n178 Y=SUM[9]
XU463 XOR2X1 $PINS A=n157 B=n24 Y=SUM[13]
XU464 XOR2X1 $PINS A=n173 B=n27 Y=SUM[10]
XU465 OR2X4 $PINS A=B[24] B=A[24] Y=n383
XU466 OR2X4 $PINS A=B[20] B=A[20] Y=n384
XU467 OR2X4 $PINS A=B[23] B=A[23] Y=n386
XU468 NAND2X1 $PINS A=B[22] B=A[22] Y=n115
XU469 INVX1 $PINS A=n183 Y=n181
XU470 XNOR2XL $PINS A=n29 B=n184 Y=SUM[8]
XU471 NAND2X1 $PINS A=n391 B=n183 Y=n29
XU472 XOR2XL $PINS A=n30 B=n187 Y=SUM[7]
XU473 XOR2X4 $PINS A=n54 B=n388 Y=SUM[33]
XU474 XOR2X4 $PINS A=n61 B=n389 Y=SUM[31]
XU475 NAND2X1 $PINS A=B[6] B=A[6] Y=n191
XU476 XNOR2X1 $PINS A=n33 B=n200 Y=SUM[4]
XU477 XOR2XL $PINS A=n32 B=n195 Y=SUM[5]
XU478 OR2X2 $PINS A=B[6] B=A[6] Y=n390
XU479 NAND2X2 $PINS A=B[33] B=A[33] Y=n53
XU481 NOR2X1 $PINS A=B[5] B=A[5] Y=n193
XU482 NAND2X1 $PINS A=B[5] B=A[5] Y=n194
XU483 NAND2X1 $PINS A=B[4] B=A[4] Y=n199
XU484 XOR2X1 $PINS A=n34 B=n203 Y=SUM[3]
XU485 XNOR2X1 $PINS A=n36 B=n214 Y=SUM[1]
XU486 NAND2X1 $PINS A=n397 B=n213 Y=n36
XU487 NAND2X1 $PINS A=B[0] B=FE_OFN5938_n5321 Y=n216
XU488 NAND2X1 $PINS A=B[2] B=A[2] Y=n207
XU489 OR2X2 $PINS A=B[1] B=A[1] Y=n397
XU490 XOR2X1 $PINS A=n97 B=n12 Y=SUM[25]
XU491 NAND2X2 $PINS A=A[26] B=B[26] Y=n93
XU492 INVX4 $PINS A=n66 Y=n64
XU493 OAI21X4 $PINS A0=n75 A1=n69 B0=n70 Y=n68
XU292 AND2X2 $PINS A=n64 B=n67 Y=n398
XU341 OAI2BB1X4 $PINS A0N=n401 A1N=n400 B0=n42 Y=n40
XU480 INVX1 $PINS A=n374 Y=n400
XU495 AND2X2 $PINS A=n50 B=n371 Y=n401
XU496 XNOR2X4 $PINS A=n40 B=n402 Y=SUM[35]
XU497 NAND2X2 $PINS A=n394 B=n39 Y=n402
.ENDS

.SUBCKT CONV_DW01_add_15 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XFE_OCPC2326_n73 CLKBUFX3 $PINS A=n73 Y=FE_OCPN6230_n73
XFE_RC_657_0 INVX1 $PINS A=n392 Y=FE_RN_354_0
XFE_RC_656_0 MX2X4 $PINS S0=n398 B=FE_RN_354_0 A=n392 Y=SUM[15]
XFE_RC_628_0 NAND2BX1 $PINS AN=n8 B=n85 Y=FE_RN_341_0
XFE_RC_627_0 NAND2BX1 $PINS AN=n85 B=n8 Y=FE_RN_342_0
XFE_RC_626_0 NAND2X4 $PINS A=FE_RN_342_0 B=FE_RN_341_0 Y=SUM[28]
XFE_RC_518_0 OAI21X4 $PINS A0=FE_OCPN6175_n91 A1=n74 B0=n75 Y=n73
XFE_RC_502_0 AOI21X2 $PINS A0=n160 A1=n402 B0=n155 Y=n153
XFE_OCPC2263_n91 CLKBUFX3 $PINS A=n91 Y=FE_OCPN6175_n91
XFE_RC_495_0 XOR2X4 $PINS A=n90 B=n396 Y=SUM[27]
XFE_OFC2254_n91 CLKINVX4 $PINS A=n91 Y=n90
XFE_OFC1944_N1246 BUFX3 $PINS A=A[35] Y=FE_OFN5971_N1246
XFE_OFC1718_n64 INVX1 $PINS A=n64 Y=n62
XFE_OFC239_n423 INVX1 $PINS A=n423 Y=n395
XFE_OFC162_n424 INVX1 $PINS A=n424 Y=n66
XU17 NOR2X1 $PINS A=A[33] B=B[33] Y=n46
XU31 XNOR2X4 $PINS A=n65 B=n5 Y=SUM[31]
XU53 XOR2X4 $PINS A=n80 B=n7 Y=SUM[29]
XU66 NOR2X2 $PINS A=n83 B=n88 Y=n81
XU67 OAI21X2 $PINS A0=n83 A1=n89 B0=n84 Y=n82
XU70 NOR2X2 $PINS A=A[28] B=B[28] Y=n83
XU73 AOI21X2 $PINS A0=n90 A1=n86 B0=n87 Y=n85
XU79 NAND2X2 $PINS A=A[27] B=B[27] Y=n89
XU82 AOI21X4 $PINS A0=n111 A1=n92 B0=n93 Y=n91
XU83 NOR2X2 $PINS A=n94 B=n97 Y=n92
XU84 OAI21X4 $PINS A0=n98 A1=n94 B0=n95 Y=n93
XU87 NOR2X4 $PINS A=A[26] B=B[26] Y=n94
XU90 OAI21X4 $PINS A0=n97 A1=n110 B0=n98 Y=n96
XU91 NAND2X4 $PINS A=n422 B=n421 Y=n97
XU108 NAND2X4 $PINS A=A[24] B=B[24] Y=n105
XU109 XOR2X4 $PINS A=n118 B=n13 Y=SUM[23]
XU111 OAI21X4 $PINS A0=n124 A1=n112 B0=n113 Y=n111
XU127 NAND2X2 $PINS A=A[22] B=B[22] Y=n122
XU130 AOI21X4 $PINS A0=n133 A1=n125 B0=n126 Y=n124
XU135 NOR2X4 $PINS A=A[21] B=B[21] Y=n127
XU138 OAI21X2 $PINS A0=n132 A1=n130 B0=n131 Y=n129
XU141 NOR2X4 $PINS A=A[20] B=B[20] Y=n130
XU142 NAND2X4 $PINS A=A[20] B=B[20] Y=n131
XU145 OAI21X4 $PINS A0=n385 A1=n134 B0=n135 Y=n133
XU304 XOR2X4 $PINS A=n123 B=n399 Y=SUM[22]
XU305 OAI21X2 $PINS A0=n1 A1=n46 B0=n47 Y=n45
XU306 NAND2X1 $PINS A=n409 B=n117 Y=n13
XU307 OAI21X2 $PINS A0=n127 A1=n131 B0=n128 Y=n126
XU308 INVX1 $PINS A=n79 Y=n77
XU309 INVX8 $PINS A=n73 Y=n386
XU310 CLKINVX3 $PINS A=n122 Y=n120
XU311 OAI2BB1X1 $PINS A0N=n173 A1N=n251 B0=n171 Y=n169
XU312 NOR2X1 $PINS A=B[6] B=A[6] Y=n204
XU313 INVX1 $PINS A=n162 Y=n160
XU314 NAND2X1 $PINS A=B[6] B=A[6] Y=n205
XU315 XOR2X2 $PINS A=n186 B=n25 Y=SUM[11]
XU316 OAI21X2 $PINS A0=n189 A1=n193 B0=n190 Y=n188
XU318 NAND2X1 $PINS A=A[15] B=B[15] Y=n162
XU319 NAND2X1 $PINS A=B[8] B=A[8] Y=n197
XU320 AOI21X1 $PINS A0=n414 A1=n219 B0=n216 Y=n214
XU321 AND2X2 $PINS A=n250 B=n168 Y=n397
XU322 NOR2X2 $PINS A=A[34] B=B[34] Y=n43
XU323 NAND2X1 $PINS A=A[33] B=B[33] Y=n47
XU324 AOI21X4 $PINS A0=n384 A1=n407 B0=n148 Y=n385
XU325 CLKINVX3 $PINS A=n150 Y=n148
XU326 NOR2X2 $PINS A=n130 B=n127 Y=n125
XU327 NAND2X2 $PINS A=n81 B=n403 Y=n74
XU328 NAND2BX2 $PINS AN=n46 B=n47 Y=n3
XU329 NAND2BX2 $PINS AN=n130 B=n131 Y=n16
XU330 AOI2BB1X1 $PINS A0N=n186 A1N=n379 B0=n182 Y=n180
XU331 INVX1 $PINS A=n411 Y=n379
XU332 NAND2XL $PINS A=n424 B=n412 Y=n57
XU334 AOI21X4 $PINS A0=n409 A1=n120 B0=n115 Y=n113
XU335 INVX1 $PINS A=n117 Y=n115
XU336 AOI21X2 $PINS A0=n417 A1=n211 B0=n208 Y=n206
XU337 INVX1 $PINS A=n210 Y=n208
XU338 AOI21X2 $PINS A0=n182 A1=n383 B0=n177 Y=n175
XU339 INVX1 $PINS A=n184 Y=n182
XU340 INVX1 $PINS A=n179 Y=n177
XU342 XNOR2X4 $PINS A=n129 B=n388 Y=SUM[21]
XU344 AOI21X4 $PINS A0=n203 A1=n416 B0=n200 Y=n198
XU345 INVX1 $PINS A=n202 Y=n200
XU346 XNOR2X2 $PINS A=n173 B=n23 Y=SUM[13]
XU347 OR2X2 $PINS A=n43 B=n46 Y=n415
XU348 NAND2X1 $PINS A=n406 B=n139 Y=n17
XU349 OAI21X4 $PINS A0=n110 A1=n104 B0=n105 Y=n103
XU350 AND2X2 $PINS A=n89 B=n86 Y=n396
XU351 INVX1 $PINS A=n88 Y=n86
XU352 NOR2X2 $PINS A=n167 B=n170 Y=n165
XU353 OAI21X4 $PINS A0=n204 A1=n206 B0=n205 Y=n203
XU354 OR2X2 $PINS A=n189 B=n380 Y=n26
XU355 INVX1 $PINS A=n190 Y=n380
XU356 NAND2X1 $PINS A=n412 B=n64 Y=n5
XU357 NAND2BX1 $PINS AN=n204 B=n205 Y=n30
XU358 OAI2BB1X2 $PINS A0N=n407 A1N=n384 B0=n150 Y=n145
XU359 NAND2BX1 $PINS AN=n94 B=n95 Y=n389
XU360 OAI221X2 $PINS A0=n1 A1=n415 B0=n43 B1=n47 C0=n44 Y=n38
XU361 NAND2BX1 $PINS AN=n220 B=n221 Y=n34
XU362 NAND2BX1 $PINS AN=n127 B=n128 Y=n388
XU363 NAND2BX1 $PINS AN=n212 B=n213 Y=n32
XU364 NAND2BX1 $PINS AN=n192 B=n193 Y=n27
XU365 OAI21X4 $PINS A0=n386 A1=n66 B0=n67 Y=n65
XU366 NOR2X2 $PINS A=n189 B=n192 Y=n187
XU367 XNOR2X1 $PINS A=n31 B=n211 Y=SUM[5]
XU368 XNOR2X1 $PINS A=n38 B=FE_OFN5971_N1246 Y=SUM[35]
XU369 NAND2X1 $PINS A=n383 B=n411 Y=n174
XU370 AOI21X2 $PINS A0=n82 A1=n403 B0=n77 Y=n75
XU371 NAND2X1 $PINS A=A[5] B=B[5] Y=n210
XU372 NAND2X2 $PINS A=A[17] B=B[17] Y=n150
XU373 NAND2X1 $PINS A=B[7] B=A[7] Y=n202
XU374 XNOR2X4 $PINS A=n191 B=n26 Y=SUM[10]
XU375 NAND2X2 $PINS A=A[30] B=B[30] Y=n67
XU376 OAI21X1 $PINS A0=n214 A1=n212 B0=n213 Y=n211
XU377 XNOR2X1 $PINS A=n33 B=n219 Y=SUM[3]
XU378 OAI21XL $PINS A0=n220 A1=n222 B0=n221 Y=n219
XU379 NAND2X2 $PINS A=n400 B=n406 Y=n134
XU380 OAI21X2 $PINS A0=n386 A1=n57 B0=n58 Y=n56
XU381 INVX1 $PINS A=n139 Y=n137
XU382 AOI21X1 $PINS A0=n418 A1=n227 B0=n224 Y=n222
XU383 INVX1 $PINS A=n226 Y=n224
XU384 NAND2X1 $PINS A=A[2] B=B[2] Y=n221
XU385 INVX1 $PINS A=n157 Y=n155
XU386 OR2X2 $PINS A=A[5] B=B[5] Y=n417
XU387 INVX1 $PINS A=n218 Y=n216
XU388 NOR2X1 $PINS A=A[4] B=B[4] Y=n212
XU389 NAND2X1 $PINS A=A[4] B=B[4] Y=n213
XU391 NAND2X1 $PINS A=A[31] B=B[31] Y=n64
XU395 XOR2X1 $PINS A=n30 B=n206 Y=SUM[6]
XU396 INVX1 $PINS A=n195 Y=n194
XU397 CLKINVX3 $PINS A=n144 Y=n142
XU399 AND2X2 $PINS A=n402 B=n405 Y=n381
XU400 INVX4 $PINS A=n133 Y=n132
XU401 NAND2X1 $PINS A=B[11] B=A[11] Y=n184
XU402 NAND2X1 $PINS A=B[13] B=A[13] Y=n171
XU403 NAND2X1 $PINS A=A[19] B=B[19] Y=n139
XU404 XOR2X2 $PINS A=n198 B=n28 Y=SUM[8]
XU405 XOR2X2 $PINS A=n194 B=n27 Y=SUM[9]
XU406 NAND2X2 $PINS A=A[18] B=B[18] Y=n144
XU407 INVX1 $PINS A=n167 Y=n250
XU408 XOR2X2 $PINS A=n158 B=n20 Y=SUM[16]
XU409 NAND2X1 $PINS A=n383 B=n179 Y=n24
XU410 NAND2X1 $PINS A=n256 B=n197 Y=n28
XU411 NAND2X2 $PINS A=n424 B=n67 Y=n390
XU412 INVX1 $PINS A=n55 Y=n53
XU413 INVX1 $PINS A=n229 Y=n227
XU414 AOI21X1 $PINS A0=n412 A1=n69 B0=n62 Y=n58
XU415 INVX1 $PINS A=n170 Y=n251
XU416 OR2X2 $PINS A=B[0] B=A[0] Y=n382
XU417 AOI21X4 $PINS A0=n187 A1=n195 B0=n188 Y=n186
XU418 OAI21X2 $PINS A0=n50 A1=n67 B0=n51 Y=n49
XU420 OAI21X1 $PINS A0=n194 A1=n192 B0=n193 Y=n191
XU422 NOR2X2 $PINS A=B[8] B=A[8] Y=n196
XU423 XNOR2X1 $PINS A=n384 B=n19 Y=SUM[17]
XU424 XOR2X2 $PINS A=n132 B=n16 Y=SUM[20]
XU425 NAND2X1 $PINS A=B[9] B=A[9] Y=n193
XU426 OR2X4 $PINS A=A[12] B=B[12] Y=n383
XU427 NAND2X1 $PINS A=n403 B=n79 Y=n7
XU428 NAND2X1 $PINS A=n150 B=n407 Y=n19
XU429 AND2X2 $PINS A=n162 B=n405 Y=n398
XU430 NAND2X4 $PINS A=n393 B=n153 Y=n384
XU431 INVX4 $PINS A=n164 Y=n392
XU432 NAND2X1 $PINS A=n251 B=n171 Y=n23
XU433 NAND2X2 $PINS A=n392 B=n381 Y=n393
XU434 NOR2X1 $PINS A=A[2] B=B[2] Y=n220
XU435 AOI21X4 $PINS A0=n145 A1=n400 B0=n142 Y=n140
XU436 NAND2X1 $PINS A=n411 B=n184 Y=n25
XU437 XNOR2X1 $PINS A=n29 B=n203 Y=SUM[7]
XU438 NAND2X2 $PINS A=n404 B=n409 Y=n112
XU439 XOR2X4 $PINS A=n140 B=n17 Y=SUM[19]
XU441 NOR2X1 $PINS A=B[9] B=A[9] Y=n192
XU443 AOI21X4 $PINS A0=n123 A1=n404 B0=n120 Y=n118
XU444 INVX1 $PINS A=n196 Y=n256
XU445 AND2X2 $PINS A=n404 B=n122 Y=n399
XU446 OR2X2 $PINS A=B[11] B=A[11] Y=n411
XU447 OAI21X4 $PINS A0=n198 A1=n196 B0=n197 Y=n195
XU448 NAND2X2 $PINS A=B[10] B=A[10] Y=n190
XU449 OR2X4 $PINS A=A[19] B=B[19] Y=n406
XU450 NAND2X1 $PINS A=n421 B=n105 Y=n12
XU451 XOR2X4 $PINS A=n1 B=n3 Y=SUM[33]
XU452 INVX2 $PINS A=n124 Y=n123
XU453 OAI21X2 $PINS A0=n167 A1=n171 B0=n168 Y=n166
XU454 OAI21X4 $PINS A0=n186 A1=n174 B0=n175 Y=n173
XU455 XOR2X4 $PINS A=n180 B=n24 Y=SUM[12]
XU456 OR2X4 $PINS A=A[17] B=B[17] Y=n407
XU457 NAND2X1 $PINS A=A[34] B=B[34] Y=n44
XU458 AOI21X4 $PINS A0=FE_OCPN6230_n73 A1=n48 B0=n49 Y=n1
XU460 INVX8 $PINS A=n111 Y=n110
XU461 AOI21X4 $PINS A0=n142 A1=n406 B0=n137 Y=n135
XU462 NOR2X2 $PINS A=n50 B=n66 Y=n48
XU463 NAND2X2 $PINS A=n413 B=n412 Y=n50
XU464 AOI21X4 $PINS A0=n165 A1=n173 B0=n166 Y=n164
XU465 NOR2X4 $PINS A=B[10] B=A[10] Y=n189
XU466 OR2X2 $PINS A=B[7] B=A[7] Y=n416
XU467 AOI21X2 $PINS A0=n392 A1=n405 B0=n160 Y=n158
XU468 XOR2X4 $PINS A=n145 B=n387 Y=SUM[18]
XU469 NAND2X1 $PINS A=B[14] B=A[14] Y=n168
XU470 NOR2X1 $PINS A=A[13] B=B[13] Y=n170
XU471 NOR2X4 $PINS A=B[14] B=A[14] Y=n167
XU472 AOI21X2 $PINS A0=n90 A1=n81 B0=n82 Y=n80
XU473 XOR2X4 $PINS A=n386 B=n390 Y=SUM[30]
XU474 OR2X4 $PINS A=A[31] B=B[31] Y=n412
XU476 NAND2X1 $PINS A=A[16] B=B[16] Y=n157
XU477 NOR2X2 $PINS A=A[27] B=B[27] Y=n88
XU478 OR2X2 $PINS A=A[3] B=B[3] Y=n414
XU479 XNOR2X1 $PINS A=n35 B=n227 Y=SUM[1]
XU480 AND2X2 $PINS A=n400 B=n144 Y=n387
XU481 XOR2X4 $PINS A=n110 B=n12 Y=SUM[24]
XU483 XNOR2X2 $PINS A=n96 B=n389 Y=SUM[26]
XU484 OR2X4 $PINS A=A[16] B=B[16] Y=n402
XU485 OR2X4 $PINS A=A[18] B=B[18] Y=n400
XU486 AND2X1 $PINS A=n413 B=n55 Y=n408
XU487 AOI21X2 $PINS A0=n413 A1=n62 B0=n53 Y=n51
XU488 NAND2X1 $PINS A=A[12] B=B[12] Y=n179
XU489 NAND2XL $PINS A=n414 B=n218 Y=n33
XU490 XOR2XL $PINS A=n34 B=n222 Y=SUM[2]
XU491 NAND2XL $PINS A=n418 B=n226 Y=n35
XU492 AND2X1 $PINS A=n382 B=n229 Y=SUM[0]
XU493 AOI2BB1X4 $PINS A0N=n426 A1N=n105 B0=n425 Y=n98
XU494 XOR2X4 $PINS A=n103 B=n395 Y=SUM[25]
XU496 XOR2X4 $PINS A=n169 B=n397 Y=SUM[14]
XU497 NAND2X1 $PINS A=n402 B=n157 Y=n20
XU498 INVX1 $PINS A=n89 Y=n87
XU500 OR2X4 $PINS A=A[29] B=B[29] Y=n403
XU501 OR2X4 $PINS A=A[22] B=B[22] Y=n404
XU502 OR2X4 $PINS A=A[15] B=B[15] Y=n405
XU503 NAND2X2 $PINS A=A[26] B=B[26] Y=n95
XU504 NAND2X1 $PINS A=A[28] B=B[28] Y=n84
XU505 NAND2X1 $PINS A=A[21] B=B[21] Y=n128
XU506 NAND2X1 $PINS A=A[29] B=B[29] Y=n79
XU507 XOR2X4 $PINS A=n56 B=n408 Y=SUM[32]
XU508 INVX1 $PINS A=n67 Y=n69
XU509 OR2X4 $PINS A=A[23] B=B[23] Y=n409
XU510 NAND2X1 $PINS A=A[23] B=B[23] Y=n117
XU511 OR2X4 $PINS A=A[32] B=B[32] Y=n413
XU512 NAND2X1 $PINS A=A[32] B=B[32] Y=n55
XU513 XOR2X1 $PINS A=n32 B=n214 Y=SUM[4]
XU514 NAND2X1 $PINS A=A[3] B=B[3] Y=n218
XU516 NAND2X1 $PINS A=n416 B=n202 Y=n29
XU517 NAND2X1 $PINS A=n417 B=n210 Y=n31
XU518 NAND2X1 $PINS A=A[1] B=B[1] Y=n226
XU519 OR2X2 $PINS A=A[1] B=B[1] Y=n418
XU520 NAND2XL $PINS A=B[0] B=A[0] Y=n229
XU333 NOR2X1 $PINS A=n43 B=n420 Y=n419
XU341 INVX1 $PINS A=n44 Y=n420
XU343 XOR2X4 $PINS A=n45 B=n419 Y=SUM[34]
XU393 OR2X4 $PINS A=A[24] B=B[24] Y=n421
XU394 INVX1 $PINS A=n421 Y=n104
XU398 NAND2BX1 $PINS AN=n83 B=n84 Y=n8
XU419 OR2X4 $PINS A=A[25] B=B[25] Y=n422
XU421 NAND2X1 $PINS A=n422 B=n102 Y=n423
XU482 OR2X2 $PINS A=A[30] B=B[30] Y=n424
XU521 AND2X2 $PINS A=A[25] B=B[25] Y=n425
XU522 INVX1 $PINS A=n425 Y=n102
XU523 NOR2X2 $PINS A=A[25] B=B[25] Y=n426
.ENDS

.SUBCKT CONV_DW01_add_9 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XFE_RC_511_0 INVX1 $PINS A=n65 Y=FE_RN_282_0
XFE_RC_510_0 MX2X4 $PINS S0=n7 B=FE_RN_282_0 A=n65 Y=SUM[30]
XFE_RC_496_0 OAI2BB2X4 $PINS A0N=n378 A1N=n75 B0=n75 B1=n378 Y=SUM[28]
XFE_OFC2070_n44 INVX1 $PINS A=n44 Y=n42
XFE_OFC1462_n74 INVX1 $PINS A=n74 Y=FE_OFN5706_n74
XFE_OFC244_n414 INVX1 $PINS A=n414 Y=n16
XFE_OFC238_n415 INVX1 $PINS A=n415 Y=n18
XU1 XNOR2X4 $PINS A=n40 B=n2 Y=SUM[35]
XU16 XOR2X4 $PINS A=n1 B=n4 Y=SUM[33]
XU23 AOI21X4 $PINS A0=n58 A1=n50 B0=n51 Y=n1
XU28 NOR2X4 $PINS A=B[32] B=A[32] Y=n52
XU34 NOR2X2 $PINS A=B[31] B=A[31] Y=n55
XU40 AOI21X2 $PINS A0=n67 A1=n401 B0=n62 Y=n60
XU49 NOR2X2 $PINS A=n68 B=n73 Y=n66
XU50 OAI21X2 $PINS A0=n68 A1=n74 B0=n69 Y=n67
XU53 NOR2X4 $PINS A=B[29] B=A[29] Y=n68
XU63 XNOR2X4 $PINS A=n81 B=n10 Y=SUM[27]
XU65 AOI21X4 $PINS A0=n85 A1=n77 B0=n78 Y=n76
XU70 NOR2X4 $PINS A=B[27] B=A[27] Y=n79
XU76 NOR2X4 $PINS A=B[26] B=A[26] Y=n82
XU80 OAI21X4 $PINS A0=n88 A1=n86 B0=n87 Y=n85
XU91 NOR2X4 $PINS A=B[24] B=A[24] Y=n91
XU97 NOR2X4 $PINS A=B[23] B=A[23] Y=n94
XU104 NOR2X4 $PINS A=B[22] B=A[22] Y=n98
XU112 NOR2X4 $PINS A=B[21] B=A[21] Y=n103
XU289 OAI21XL $PINS A0=n45 A1=n49 B0=n46 Y=n44
XU290 NAND2X1 $PINS A=B[30] B=A[30] Y=n64
XU291 NAND2X1 $PINS A=n80 B=n377 Y=n10
XU292 NAND2BX2 $PINS AN=n128 B=n129 Y=n21
XU293 OAI21X2 $PINS A0=n56 A1=n52 B0=n53 Y=n51
XU294 NAND2X1 $PINS A=A[6] B=B[6] Y=n188
XU295 XNOR2X1 $PINS A=n30 B=n389 Y=SUM[7]
XU296 NAND2X1 $PINS A=n385 B=n386 Y=n387
XU297 INVX1 $PINS A=n147 Y=n385
XU298 NAND2X2 $PINS A=B[23] B=A[23] Y=n95
XU299 AOI21X4 $PINS A0=n143 A1=n402 B0=n140 Y=n138
XU300 INVX1 $PINS A=n142 Y=n140
XU301 OAI21X2 $PINS A0=n152 A1=n150 B0=n151 Y=n149
XU302 INVX1 $PINS A=n153 Y=n152
XU303 NOR2X2 $PINS A=B[25] B=A[25] Y=n86
XU305 NAND2X4 $PINS A=B[26] B=A[26] Y=n83
XU306 NOR2X1 $PINS A=A[5] B=B[5] Y=n190
XU307 NAND2BXL $PINS AN=n150 B=n151 Y=n25
XU308 NAND2BX1 $PINS AN=n106 B=n107 Y=n17
XU309 NAND2X2 $PINS A=n145 B=n153 Y=n391
XU310 INVX1 $PINS A=n151 Y=n386
XU312 NAND2X1 $PINS A=n398 B=n396 Y=n110
XU313 OR2X2 $PINS A=B[19] B=A[19] Y=n396
XU314 INVX1 $PINS A=n64 Y=n62
XU315 NAND2X1 $PINS A=A[14] B=B[14] Y=n142
XU316 NAND2XL $PINS A=B[13] B=A[13] Y=n148
XU317 NOR2X2 $PINS A=A[12] B=B[12] Y=n150
XU318 NAND2X2 $PINS A=A[12] B=B[12] Y=n151
XU319 NAND2X1 $PINS A=B[28] B=A[28] Y=n74
XU320 NAND2X2 $PINS A=B[20] B=A[20] Y=n107
XU321 NAND2X2 $PINS A=B[22] B=A[22] Y=n99
XU323 AOI21X1 $PINS A0=n389 A1=n407 B0=n180 Y=n178
XU324 NOR2X2 $PINS A=n91 B=n94 Y=n366
XU325 NOR2BX2 $PINS AN=n56 B=n55 Y=n395
XU326 OAI2BB1X4 $PINS A0N=n369 A1N=n75 B0=n60 Y=n58
XU327 NAND2BX1 $PINS AN=n91 B=n92 Y=n13
XU328 NAND2BX2 $PINS AN=n82 B=n83 Y=n11
XU329 AOI21X2 $PINS A0=n162 A1=n406 B0=n157 Y=n155
XU330 INVX1 $PINS A=n159 Y=n157
XU331 OAI21X4 $PINS A0=n122 A1=n110 B0=n111 Y=n109
XU332 XOR2X2 $PINS A=n22 B=n138 Y=SUM[15]
XU333 NAND2BX2 $PINS AN=n86 B=n87 Y=n12
XU334 AND3X4 $PINS A=n391 B=n387 C=n148 Y=n144
XU335 AOI21X4 $PINS A0=n97 A1=n366 B0=n90 Y=n88
XU336 AOI21X1 $PINS A0=n409 A1=n189 B0=n186 Y=n184
XU337 INVX1 $PINS A=n188 Y=n186
XU338 NOR2BX2 $PINS AN=n46 B=n45 Y=n399
XU339 AOI21X1 $PINS A0=n412 A1=n403 B0=n365 Y=n200
XU340 INVX1 $PINS A=n204 Y=n365
XU341 AOI21X2 $PINS A0=n165 A1=n410 B0=n162 Y=n160
XU342 CLKINVX3 $PINS A=n164 Y=n162
XU343 NAND2BX1 $PINS AN=n190 B=n191 Y=n32
XU344 NAND2BX1 $PINS AN=n198 B=n199 Y=n34
XU345 XNOR2X2 $PINS A=n171 B=n28 Y=SUM[9]
XU346 AOI21X1 $PINS A0=n180 A1=n405 B0=n175 Y=n173
XU347 INVX1 $PINS A=n182 Y=n180
XU348 INVX1 $PINS A=n177 Y=n175
XU349 OAI2BB1X2 $PINS A0N=n228 A1N=n372 B0=n104 Y=n102
XU351 NAND2BX1 $PINS AN=n94 B=n95 Y=n14
XU352 INVX1 $PINS A=n137 Y=n135
XU353 AOI21X2 $PINS A0=n121 A1=n398 B0=n118 Y=n116
XU354 NAND2XL $PINS A=n409 B=n188 Y=n31
XU355 XNOR2X2 $PINS A=n165 B=n393 Y=SUM[10]
XU356 AND2X2 $PINS A=n66 B=n401 Y=n369
XU357 INVX2 $PINS A=n97 Y=n96
XU359 INVX4 $PINS A=n144 Y=n143
XU360 OR2XL $PINS A=A[17] B=B[17] Y=n368
XU361 NAND2X2 $PINS A=B[31] B=A[31] Y=n56
XU362 XOR2X2 $PINS A=n15 B=n100 Y=SUM[22]
XU363 NAND2X1 $PINS A=n406 B=n159 Y=n26
XU364 INVX8 $PINS A=n76 Y=n75
XU365 NOR2X2 $PINS A=B[34] B=A[34] Y=n45
XU366 NAND2X1 $PINS A=A[11] B=B[11] Y=n159
XU367 CLKINVX3 $PINS A=n184 Y=n389
XU368 INVX2 $PINS A=n73 Y=n71
XU369 NAND2X1 $PINS A=n137 B=n397 Y=n22
XU370 XNOR2X1 $PINS A=n31 B=n189 Y=SUM[6]
XU371 OAI21X4 $PINS A0=n96 A1=n94 B0=n95 Y=n93
XU372 OR2X2 $PINS A=A[6] B=B[6] Y=n409
XU373 NAND2X1 $PINS A=B[4] B=A[4] Y=n196
XU374 INVX4 $PINS A=n58 Y=n57
XU375 XOR2X4 $PINS A=n47 B=n399 Y=SUM[34]
XU376 XOR2X1 $PINS A=n32 B=n192 Y=SUM[5]
XU377 XNOR2X2 $PINS A=n143 B=n23 Y=SUM[14]
XU378 NAND2X2 $PINS A=B[25] B=A[25] Y=n87
XU379 XOR2X2 $PINS A=n152 B=n25 Y=SUM[12]
XU380 XNOR2X2 $PINS A=n149 B=n24 Y=SUM[13]
XU381 XOR2X1 $PINS A=n34 B=n200 Y=SUM[3]
XU382 NAND2X1 $PINS A=n407 B=n182 Y=n30
XU383 XOR2X1 $PINS A=n178 B=n29 Y=SUM[8]
XU386 INVX2 $PINS A=n103 Y=n228
XU387 INVX1 $PINS A=n107 Y=n372
XU388 INVX1 $PINS A=n115 Y=n113
XU391 NAND2X1 $PINS A=A[15] B=B[15] Y=n137
XU392 NAND2X1 $PINS A=B[21] B=A[21] Y=n104
XU393 OAI21X2 $PINS A0=n79 A1=n83 B0=n80 Y=n78
XU394 OR2X2 $PINS A=A[9] B=B[9] Y=n408
XU395 OAI21X2 $PINS A0=n91 A1=n95 B0=n92 Y=n90
XU396 XOR2X4 $PINS A=n54 B=n371 Y=SUM[32]
XU397 AND2X2 $PINS A=n217 B=n53 Y=n371
XU398 OAI21X2 $PINS A0=n1 A1=n404 B0=n42 Y=n40
XU399 OR2X2 $PINS A=n45 B=n48 Y=n404
XU401 NOR2X2 $PINS A=n79 B=n82 Y=n77
XU402 NAND2X2 $PINS A=n388 B=n133 Y=n131
XU403 NAND2X1 $PINS A=n385 B=n148 Y=n24
XU404 NAND2X4 $PINS A=A[16] B=B[16] Y=n129
XU405 NOR2X2 $PINS A=n52 B=n55 Y=n50
XU406 NOR2X2 $PINS A=n103 B=n106 Y=n101
XU407 OR2X2 $PINS A=A[2] B=B[2] Y=n412
XU408 OAI2BB1X1 $PINS A0N=n411 A1N=n211 B0=n210 Y=n403
XU409 INVX1 $PINS A=n213 Y=n211
XU410 NAND2X1 $PINS A=A[5] B=B[5] Y=n191
XU411 NAND2X2 $PINS A=B[27] B=A[27] Y=n80
XU413 NAND2BX2 $PINS AN=n48 B=n49 Y=n4
XU414 NAND2X2 $PINS A=n71 B=n74 Y=n378
XU415 NAND2BX1 $PINS AN=n98 B=n99 Y=n15
XU416 AND2X2 $PINS A=n405 B=n407 Y=n373
XU417 OR2X2 $PINS A=B[0] B=A[0] Y=n374
XU418 OR2XL $PINS A=B[27] B=A[27] Y=n377
XU419 CLKINVX3 $PINS A=n109 Y=n108
XU420 AOI21X2 $PINS A0=n396 A1=n118 B0=n113 Y=n111
XU421 NAND2X1 $PINS A=B[19] B=A[19] Y=n115
XU422 OAI21X4 $PINS A0=n84 A1=n82 B0=n83 Y=n81
XU423 INVX1 $PINS A=n68 Y=n220
XU424 OAI21X1 $PINS A0=n1 A1=n48 B0=n49 Y=n47
XU425 NAND2X1 $PINS A=n408 B=n170 Y=n28
XU426 INVX1 $PINS A=n166 Y=n165
XU427 NAND2X1 $PINS A=n410 B=n164 Y=n393
XU428 NAND2XL $PINS A=n405 B=n177 Y=n29
XU429 AND2X4 $PINS A=n388 B=n133 Y=n376
XU430 AOI21X2 $PINS A0=n397 A1=n140 B0=n135 Y=n133
XU432 OR2X4 $PINS A=A[14] B=B[14] Y=n402
XU433 XOR2X4 $PINS A=n88 B=n12 Y=SUM[25]
XU434 XOR2X4 $PINS A=n116 B=n18 Y=SUM[19]
XU435 INVX1 $PINS A=n52 Y=n217
XU436 NAND2X1 $PINS A=A[18] B=B[18] Y=n120
XU437 XOR2X4 $PINS A=n96 B=n14 Y=SUM[23]
XU438 AND2X2 $PINS A=n220 B=n69 Y=n381
XU439 INVX1 $PINS A=n170 Y=n168
XU440 XOR2X4 $PINS A=n376 B=n21 Y=SUM[16]
XU441 XNOR2X4 $PINS A=n70 B=n381 Y=SUM[29]
XU442 NAND2X2 $PINS A=n406 B=n410 Y=n154
XU443 NAND2X2 $PINS A=n373 B=n389 Y=n390
XU444 OAI21X4 $PINS A0=n57 A1=n55 B0=n56 Y=n54
XU445 NOR2X2 $PINS A=n147 B=n150 Y=n145
XU446 NOR2X2 $PINS A=n125 B=n128 Y=n123
XU447 OAI21X2 $PINS A0=n125 A1=n129 B0=n126 Y=n124
XU448 XNOR2X4 $PINS A=n93 B=n13 Y=SUM[24]
XU449 NAND2X1 $PINS A=B[34] B=A[34] Y=n46
XU450 OAI21XL $PINS A0=n198 A1=n200 B0=n199 Y=n197
XU451 NAND2X1 $PINS A=B[3] B=A[3] Y=n199
XU452 NOR2X2 $PINS A=A[17] B=B[17] Y=n125
XU453 NOR2X4 $PINS A=A[16] B=B[16] Y=n128
XU454 OAI21X4 $PINS A0=n376 A1=n128 B0=n129 Y=n127
XU455 INVX1 $PINS A=n120 Y=n118
XU456 AND2X2 $PINS A=n398 B=n120 Y=n392
XU457 OR2X4 $PINS A=A[10] B=B[10] Y=n410
XU458 OAI21XL $PINS A0=n192 A1=n190 B0=n191 Y=n189
XU459 XOR2X4 $PINS A=n121 B=n392 Y=SUM[18]
XU460 NAND2X1 $PINS A=A[10] B=B[10] Y=n164
XU461 AOI21X2 $PINS A0=n75 A1=n66 B0=n67 Y=n65
XU462 NAND2X1 $PINS A=B[33] B=A[33] Y=n49
XU463 AOI21X4 $PINS A0=n123 A1=n131 B0=n124 Y=n122
XU464 NOR2X2 $PINS A=B[20] B=A[20] Y=n106
XU465 AOI21X4 $PINS A0=n109 A1=n101 B0=n102 Y=n100
XU466 XOR2X4 $PINS A=n108 B=n17 Y=SUM[20]
XU467 OR2X2 $PINS A=n144 B=n132 Y=n388
XU468 OAI21X4 $PINS A0=n166 A1=n154 B0=n155 Y=n153
XU469 XNOR2X4 $PINS A=n127 B=n20 Y=SUM[17]
XU470 AOI21X4 $PINS A0=n171 A1=n408 B0=n168 Y=n166
XU471 NAND2X4 $PINS A=n390 B=n173 Y=n171
XU472 AOI21X1 $PINS A0=n197 A1=n400 B0=n194 Y=n192
XU473 AOI21X4 $PINS A0=n75 A1=n71 B0=FE_OFN5706_n74 Y=n70
XU474 INVX4 $PINS A=n122 Y=n121
XU475 NOR2X1 $PINS A=B[3] B=A[3] Y=n198
XU476 NOR2X1 $PINS A=B[28] B=A[28] Y=n73
XU477 XOR2X4 $PINS A=n160 B=n26 Y=SUM[11]
XU478 NAND2X1 $PINS A=A[7] B=B[7] Y=n182
XU479 NAND2X1 $PINS A=A[17] B=B[17] Y=n126
XU480 XOR2X4 $PINS A=n84 B=n11 Y=SUM[26]
XU481 NOR2X1 $PINS A=n108 B=n106 Y=n384
XU482 OR2X2 $PINS A=n384 B=n372 Y=n105
XU483 XNOR2X4 $PINS A=n105 B=n16 Y=SUM[21]
XU484 NOR2X2 $PINS A=A[13] B=B[13] Y=n147
XU485 INVX4 $PINS A=n85 Y=n84
XU486 OAI21X4 $PINS A0=n100 A1=n98 B0=n99 Y=n97
XU487 NOR2X2 $PINS A=B[33] B=A[33] Y=n48
XU488 OR2X2 $PINS A=A[18] B=B[18] Y=n398
XU489 OR2X2 $PINS A=A[7] B=B[7] Y=n407
XU490 NAND2X1 $PINS A=A[9] B=B[9] Y=n170
XU491 OR2X4 $PINS A=A[8] B=B[8] Y=n405
XU492 OR2X4 $PINS A=A[15] B=B[15] Y=n397
XU493 OR2X2 $PINS A=B[4] B=A[4] Y=n400
XU494 OR2X2 $PINS A=B[35] B=A[35] Y=n413
XU495 OR2X4 $PINS A=A[11] B=B[11] Y=n406
XU497 NAND2X1 $PINS A=A[2] B=B[2] Y=n204
XU498 NAND2X1 $PINS A=n402 B=n397 Y=n132
XU499 NAND2X1 $PINS A=n368 B=n126 Y=n20
XU500 NAND2XL $PINS A=n411 B=n210 Y=n36
XU501 NAND2X1 $PINS A=A[8] B=B[8] Y=n177
XU502 NAND2XL $PINS A=A[1] B=B[1] Y=n210
XU503 AND2X1 $PINS A=n374 B=n213 Y=SUM[0]
XU504 INVX1 $PINS A=n196 Y=n194
XU505 NAND2X1 $PINS A=n402 B=n142 Y=n23
XU506 NAND2X1 $PINS A=n401 B=n64 Y=n7
XU507 XNOR2X4 $PINS A=n57 B=n395 Y=SUM[31]
XU508 XNOR2X1 $PINS A=n33 B=n197 Y=SUM[4]
XU509 NAND2X1 $PINS A=n400 B=n196 Y=n33
XU510 NAND2X1 $PINS A=B[32] B=A[32] Y=n53
XU511 NAND2X1 $PINS A=B[29] B=A[29] Y=n69
XU512 NAND2X2 $PINS A=B[24] B=A[24] Y=n92
XU513 OR2X4 $PINS A=B[30] B=A[30] Y=n401
XU514 XNOR2X1 $PINS A=n36 B=n211 Y=SUM[1]
XU515 XNOR2X1 $PINS A=n35 B=n403 Y=SUM[2]
XU516 NAND2X1 $PINS A=n412 B=n204 Y=n35
XU518 NAND2X2 $PINS A=n413 B=n39 Y=n2
XU519 NAND2X1 $PINS A=B[35] B=A[35] Y=n39
XU520 OR2X2 $PINS A=A[1] B=B[1] Y=n411
XU521 NAND2XL $PINS A=B[0] B=A[0] Y=n213
XU358 AND2X2 $PINS A=n228 B=n104 Y=n414
XU522 AND2X2 $PINS A=n115 B=n396 Y=n415
.ENDS

.SUBCKT CONV_DW01_sub_4 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI DIFF[35] DIFF[34]
+ DIFF[33] DIFF[32] DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO
XFE_OFC2046_n107 CLKINVX3 $PINS A=n106 Y=FE_OFN6059_n107
XFE_OFC2045_n107 CLKINVX3 $PINS A=n107 Y=n106
XFE_OFC1904_N1028 INVX1 $PINS A=B[29] Y=n280
XFE_OFC1853_N1011 CLKINVX3 $PINS A=B[12] Y=n297
XFE_OFC1656_N1020 INVX1 $PINS A=B[21] Y=n288
XFE_OFC1447_n178 CLKINVX3 $PINS A=n178 Y=n176
XFE_OFC482_n48 INVX1 $PINS A=n48 Y=n46
XFE_OFC240_n100 INVX1 $PINS A=n100 Y=FE_DBTN161_n100
XFE_OFC173_n455 INVX1 $PINS A=n455 Y=n222
XU37 NOR2X1 $PINS A=n278 B=A[31] Y=n57
XU45 NOR2X2 $PINS A=n66 B=n73 Y=n64
XU61 NOR2X2 $PINS A=n280 B=A[29] Y=n73
XU84 AOI21X2 $PINS A0=n103 A1=n446 B0=n96 Y=n90
XU103 OAI21X2 $PINS A0=n120 A1=n108 B0=n109 Y=n107
XU113 AOI21X4 $PINS A0=n119 A1=n445 B0=n116 Y=n114
XU122 AOI21X4 $PINS A0=n121 A1=n129 B0=n122 Y=n120
XU137 OAI21X4 $PINS A0=n130 A1=n158 B0=n131 Y=n129
XU140 NOR2X2 $PINS A=n134 B=n139 Y=n132
XU144 NOR2X2 $PINS A=n288 B=A[21] Y=n134
XU346 INVX1 $PINS A=n173 Y=n171
XU347 OAI21X1 $PINS A0=n222 A1=n224 B0=n223 Y=n221
XU348 XOR2X1 $PINS A=n210 B=n27 Y=DIFF[9]
XU349 AOI21X1 $PINS A0=n116 A1=n447 B0=n111 Y=n109
XU350 INVX1 $PINS A=n191 Y=n189
XU351 INVX2 $PINS A=n120 Y=n119
XU352 XOR2X1 $PINS A=n119 B=n441 Y=DIFF[24]
XU353 NOR2X1 $PINS A=A[16] B=n293 Y=n164
XU354 OR2X2 $PINS A=n134 B=n142 Y=n421
XU355 NAND2X2 $PINS A=n421 B=n135 Y=n133
XU356 NAND2X1 $PINS A=FE_OFN6059_n107 B=n423 Y=n424
XU357 NAND2X1 $PINS A=n424 B=n70 Y=n68
XU359 INVX1 $PINS A=n69 Y=n423
XU360 NAND2X1 $PINS A=n71 B=n91 Y=n69
XU361 NOR2X1 $PINS A=n425 B=n83 Y=n427
XU362 NOR2X2 $PINS A=n427 B=n65 Y=n63
XU363 INVX1 $PINS A=n64 Y=n425
XU365 INVX1 $PINS A=n83 Y=n85
XU366 OAI21XL $PINS A0=n66 A1=n76 B0=n67 Y=n65
XU367 AOI21XL $PINS A0=n92 A1=n71 B0=n72 Y=n70
XU368 XNOR2X1 $PINS A=n42 B=n2 Y=DIFF[34]
XU369 INVX1 $PINS A=n196 Y=n194
XU370 NAND2X1 $PINS A=A[11] B=n298 Y=n196
XU371 AOI21X4 $PINS A0=n60 A1=FE_OFN6059_n107 B0=n61 Y=n1
XU372 NAND2BX1 $PINS AN=n226 B=n227 Y=n31
XU373 NOR2X1 $PINS A=A[5] B=n304 Y=n226
XU374 OAI21X2 $PINS A0=n123 A1=n127 B0=n124 Y=n122
XU375 OAI21X2 $PINS A0=n128 A1=n126 B0=n127 Y=n125
XU376 NAND2X1 $PINS A=n287 B=A[22] Y=n127
XU377 NAND2X1 $PINS A=A[16] B=n293 Y=n165
XU378 NOR2X1 $PINS A=n287 B=A[22] Y=n126
XU379 NOR2X1 $PINS A=n62 B=n89 Y=n60
XU380 NAND2X2 $PINS A=A[18] B=n291 Y=n156
XU381 NOR2X2 $PINS A=A[17] B=n292 Y=n161
XU382 INVX1 $PINS A=B[8] Y=n301
XU383 NOR2X1 $PINS A=n82 B=n73 Y=n71
XU384 NOR2X1 $PINS A=n277 B=A[32] Y=n54
XU385 NAND2X1 $PINS A=n277 B=A[32] Y=n55
XU387 INVX1 $PINS A=n225 Y=n224
XU388 NAND2X1 $PINS A=A[8] B=n301 Y=n214
XU390 NAND2X1 $PINS A=n279 B=A[30] Y=n67
XU391 XOR2X2 $PINS A=n157 B=n431 Y=DIFF[18]
XU392 INVX1 $PINS A=B[23] Y=n286
XU393 XNOR2X2 $PINS A=n88 B=n8 Y=DIFF[28]
XU394 XOR2X2 $PINS A=n1 B=n5 Y=DIFF[31]
XU395 XOR2X2 $PINS A=n143 B=n16 Y=DIFF[20]
XU396 NOR2X1 $PINS A=n161 B=n164 Y=n159
XU397 OAI21X4 $PINS A0=n1 A1=n57 B0=n58 Y=n56
XU398 AOI21X4 $PINS A0=n176 A1=n436 B0=n171 Y=n169
XU399 NOR2BX1 $PINS AN=n55 B=n54 Y=n439
XU400 OAI21X1 $PINS A0=n62 A1=n90 B0=n63 Y=n61
XU401 AOI21X2 $PINS A0=n203 A1=n451 B0=n200 Y=n198
XU402 INVX1 $PINS A=n202 Y=n200
XU404 NAND2BX1 $PINS AN=n222 B=n223 Y=n30
XU405 NAND2BX1 $PINS AN=n234 B=n235 Y=n33
XU406 NAND2X1 $PINS A=n84 B=n83 Y=n8
XU407 OAI2BB1X1 $PINS A0N=n145 A1N=n428 B0=n142 Y=n138
XU408 INVX1 $PINS A=n139 Y=n428
XU409 NAND2BX1 $PINS AN=n57 B=n58 Y=n5
XU410 AOI21X1 $PINS A0=n221 A1=n452 B0=n218 Y=n216
XU411 INVX1 $PINS A=n220 Y=n218
XU412 NAND2BX1 $PINS AN=n238 B=n239 Y=n34
XU413 NAND2BXL $PINS AN=n150 B=n151 Y=n17
XU414 NAND2XL $PINS A=n449 B=n196 Y=n25
XU415 AND2X1 $PINS A=n101 B=FE_DBTN161_n100 Y=n434
XU416 NAND2BX1 $PINS AN=n164 B=n165 Y=n20
XU417 AOI21X1 $PINS A0=n197 A1=n449 B0=n194 Y=n192
XU418 NAND2BX1 $PINS AN=n40 B=n41 Y=n2
XU419 NAND2BX1 $PINS AN=n139 B=n142 Y=n16
XU420 NAND2BX1 $PINS AN=n126 B=n127 Y=n14
XU421 NAND2BX1 $PINS AN=n82 B=n64 Y=n62
XU422 NOR2X1 $PINS A=n40 B=n47 Y=n38
XU423 XNOR2X2 $PINS A=n163 B=n19 Y=DIFF[17]
XU424 AOI21X2 $PINS A0=n157 A1=n137 B0=n138 Y=n136
XU425 INVX4 $PINS A=n158 Y=n157
XU426 CLKINVX3 $PINS A=n129 Y=n128
XU427 NAND2X1 $PINS A=n448 B=n450 Y=n204
XU428 NAND2BX1 $PINS AN=n161 B=n162 Y=n19
XU429 OAI21X1 $PINS A0=n236 A1=n234 B0=n235 Y=n233
XU430 INVX1 $PINS A=n237 Y=n236
XU431 INVX1 $PINS A=n90 Y=n92
XU432 NAND2BX1 $PINS AN=n134 B=n135 Y=n15
XU433 NAND2BX1 $PINS AN=n123 B=n124 Y=n13
XU434 AOI21X4 $PINS A0=n179 A1=n442 B0=n176 Y=n174
XU435 INVX1 $PINS A=n82 Y=n84
XU436 OAI21XL $PINS A0=n43 A1=n1 B0=n44 Y=n42
XU437 XNOR2X1 $PINS A=n29 B=n221 Y=DIFF[7]
XU438 AOI21X2 $PINS A0=n145 A1=n132 B0=n133 Y=n131
XU439 OR2X2 $PINS A=A[9] B=n300 Y=n448
XU440 XOR2X1 $PINS A=n192 B=n24 Y=DIFF[12]
XU441 AOI21X2 $PINS A0=n157 A1=n144 B0=n145 Y=n143
XU442 INVX1 $PINS A=B[9] Y=n300
XU443 NAND2X1 $PINS A=n286 B=A[23] Y=n124
XU444 OAI21XL $PINS A0=n161 A1=n165 B0=n162 Y=n160
XU445 XOR2X4 $PINS A=n56 B=n439 Y=DIFF[32]
XU446 INVXL $PINS A=n52 Y=n50
XU447 AND2X2 $PINS A=n445 B=n118 Y=n441
XU448 NAND2X1 $PINS A=A[17] B=n292 Y=n162
XU449 INVX1 $PINS A=B[19] Y=n290
XU451 NOR2X2 $PINS A=n281 B=A[28] Y=n82
XU452 AOI21X1 $PINS A0=n53 A1=n45 B0=n46 Y=n44
XU453 INVX1 $PINS A=n47 Y=n45
XU455 NAND2X1 $PINS A=A[7] B=n302 Y=n220
XU456 NAND2X1 $PINS A=A[9] B=n300 Y=n209
XU457 NOR2X1 $PINS A=n275 B=A[34] Y=n40
XU458 NOR2X1 $PINS A=n54 B=n57 Y=n52
XU459 NAND2X1 $PINS A=n288 B=A[21] Y=n135
XU460 NAND2X1 $PINS A=n285 B=A[24] Y=n118
XU461 XNOR2X1 $PINS A=n185 B=n23 Y=DIFF[13]
XU462 XOR2X1 $PINS A=n215 B=n433 Y=DIFF[8]
XU463 XNOR2X1 $PINS A=n203 B=n26 Y=DIFF[10]
XU464 XOR2X1 $PINS A=n128 B=n14 Y=DIFF[22]
XU465 XNOR2X2 $PINS A=n106 B=n434 Y=DIFF[26]
XU466 INVX1 $PINS A=n198 Y=n197
XU467 NOR2BX1 $PINS AN=n144 B=n139 Y=n137
XU468 INVX1 $PINS A=n98 Y=n96
XU469 OR2X2 $PINS A=n204 B=n216 Y=n429
XU470 NAND2X2 $PINS A=n429 B=n205 Y=n203
XU471 AOI21X4 $PINS A0=n167 A1=n159 B0=n160 Y=n158
XU472 INVX1 $PINS A=B[22] Y=n287
XU473 INVX1 $PINS A=B[28] Y=n281
XU474 INVX1 $PINS A=B[30] Y=n279
XU475 NAND2X1 $PINS A=A[15] B=n294 Y=n173
XU476 NOR2X1 $PINS A=A[3] B=n306 Y=n234
XU477 XOR2X1 $PINS A=n166 B=n20 Y=DIFF[16]
XU478 INVX1 $PINS A=B[17] Y=n292
XU479 INVX1 $PINS A=B[16] Y=n293
XU480 INVX1 $PINS A=B[2] Y=n307
XU481 INVX1 $PINS A=B[5] Y=n304
XU482 INVX1 $PINS A=B[6] Y=n303
XU483 INVX1 $PINS A=B[18] Y=n291
XU484 INVX1 $PINS A=B[27] Y=n282
XU485 INVX1 $PINS A=B[11] Y=n298
XU486 INVX1 $PINS A=B[3] Y=n306
XU487 NOR2X1 $PINS A=n276 B=A[33] Y=n47
XU488 OAI21XL $PINS A0=n54 A1=n58 B0=n55 Y=n53
XU489 NOR2X1 $PINS A=n307 B=A[2] Y=n238
XU490 INVX1 $PINS A=B[25] Y=n284
XU491 NOR2X2 $PINS A=n123 B=n126 Y=n121
XU492 INVX1 $PINS A=B[24] Y=n285
XU493 INVX1 $PINS A=n155 Y=n258
XU494 INVX1 $PINS A=B[26] Y=n283
XU495 NAND2X1 $PINS A=n282 B=A[27] Y=n98
XU497 NAND2X1 $PINS A=A[10] B=n299 Y=n202
XU498 INVX1 $PINS A=n209 Y=n207
XU499 NAND2X1 $PINS A=n436 B=n173 Y=n21
XU500 NAND2X1 $PINS A=n284 B=A[25] Y=n113
XU501 OR2X2 $PINS A=n284 B=A[25] Y=n447
XU502 AND2X2 $PINS A=n442 B=n178 Y=n432
XU503 NAND2X1 $PINS A=n283 B=A[26] Y=n101
XU504 XNOR2X1 $PINS A=n32 B=n233 Y=DIFF[4]
XU505 INVX1 $PINS A=n73 Y=n247
XU506 AND2X2 $PINS A=n246 B=n67 Y=n437
XU507 INVX1 $PINS A=n66 Y=n246
XU508 OR2X2 $PINS A=A[14] B=n295 Y=n442
XU509 NAND2X1 $PINS A=n132 B=n144 Y=n130
XU510 OAI21X1 $PINS A0=n106 A1=n89 B0=n90 Y=n88
XU511 INVX1 $PINS A=n216 Y=n215
XU512 XOR2X2 $PINS A=n174 B=n21 Y=DIFF[15]
XU513 NAND2X1 $PINS A=A[6] B=n303 Y=n223
XU514 XNOR2X1 $PINS A=n49 B=n3 Y=DIFF[33]
XU516 AOI21X1 $PINS A0=n443 A1=n194 B0=n189 Y=n187
XU517 OR2X4 $PINS A=A[15] B=n294 Y=n436
XU518 INVX1 $PINS A=n167 Y=n166
XU519 AOI21X1 $PINS A0=n92 A1=n84 B0=n85 Y=n79
XU520 XOR2X2 $PINS A=n136 B=n15 Y=DIFF[21]
XU521 XOR2X2 $PINS A=n152 B=n17 Y=DIFF[19]
XU522 NAND2X1 $PINS A=n444 B=n184 Y=n23
XU523 INVX1 $PINS A=n118 Y=n116
XU524 OAI21XL $PINS A0=n228 A1=n226 B0=n227 Y=n225
XU525 XOR2X1 $PINS A=n31 B=n228 Y=DIFF[5]
XU526 AOI21X1 $PINS A0=n453 A1=n233 B0=n230 Y=n228
XU528 NOR2X1 $PINS A=n283 B=A[26] Y=n100
XU529 NAND2X1 $PINS A=A[19] B=n290 Y=n151
XU530 XNOR2X2 $PINS A=n125 B=n13 Y=DIFF[23]
XU531 NOR2X2 $PINS A=n150 B=n155 Y=n144
XU532 NAND2X1 $PINS A=A[14] B=n295 Y=n178
XU533 XOR2X1 $PINS A=n68 B=n437 Y=DIFF[30]
XU534 NAND2XL $PINS A=n52 B=n45 Y=n43
XU535 NAND2X1 $PINS A=n38 B=n52 Y=n36
XU536 AOI21X2 $PINS A0=n157 A1=n258 B0=n154 Y=n152
XU537 OAI21X2 $PINS A0=n168 A1=n180 B0=n169 Y=n167
XU538 INVX1 $PINS A=n180 Y=n179
XU539 NOR2X1 $PINS A=A[18] B=n291 Y=n155
XU540 OAI21XL $PINS A0=n1 A1=n50 B0=n51 Y=n49
XU542 OAI21X2 $PINS A0=n150 A1=n156 B0=n151 Y=n145
XU543 NAND2X1 $PINS A=n443 B=n449 Y=n186
XU544 AOI21X1 $PINS A0=n448 A1=n212 B0=n207 Y=n205
XU545 NAND2X1 $PINS A=n289 B=A[20] Y=n142
XU546 NAND2X1 $PINS A=A[12] B=n297 Y=n191
XU547 OR2X2 $PINS A=A[12] B=n297 Y=n443
XU548 OAI21X2 $PINS A0=n166 A1=n164 B0=n165 Y=n163
XU549 OAI21X4 $PINS A0=n186 A1=n198 B0=n187 Y=n185
XU550 NOR2X2 $PINS A=A[19] B=n290 Y=n150
XU551 OR2X2 $PINS A=n285 B=A[24] Y=n445
XU552 NOR2X1 $PINS A=n289 B=A[20] Y=n139
XU553 NAND2X1 $PINS A=A[13] B=n296 Y=n184
XU554 NOR2X2 $PINS A=n286 B=A[23] Y=n123
XU555 OR2X1 $PINS A=A[4] B=n305 Y=n453
XU556 XOR2X2 $PINS A=n179 B=n432 Y=DIFF[14]
XU557 AOI21X1 $PINS A0=n215 A1=n450 B0=n212 Y=n210
XU558 NAND2X1 $PINS A=n436 B=n442 Y=n168
XU559 AOI21X4 $PINS A0=n185 A1=n444 B0=n182 Y=n180
XU560 AND2X2 $PINS A=n258 B=n156 Y=n431
XU562 NAND2XL $PINS A=n452 B=n220 Y=n29
XU563 NAND2XL $PINS A=n448 B=n209 Y=n27
XU564 AND2X1 $PINS A=n450 B=n214 Y=n433
XU565 AND2X1 $PINS A=n247 B=n76 Y=n438
XU566 NAND2XL $PINS A=n451 B=n202 Y=n26
XU567 NAND2X1 $PINS A=n445 B=n447 Y=n108
XU568 AND2X1 $PINS A=n446 B=n98 Y=n440
XU569 XOR2X2 $PINS A=n114 B=n435 Y=DIFF[25]
XU570 NAND2XL $PINS A=n113 B=n447 Y=n435
XU571 NAND2X1 $PINS A=FE_DBTN161_n100 B=n446 Y=n89
XU572 INVX1 $PINS A=n101 Y=n103
XU573 NAND2XL $PINS A=n453 B=n232 Y=n32
XU574 NAND2X1 $PINS A=n281 B=A[28] Y=n83
XU575 NAND2X1 $PINS A=n276 B=A[33] Y=n48
XU576 OAI21XL $PINS A0=n238 A1=n454 B0=n239 Y=n237
XU577 NAND2XL $PINS A=A[5] B=n304 Y=n227
XU578 OR2XL $PINS A=B[1] B=B[0] Y=n454
XU579 NAND2XL $PINS A=n275 B=A[34] Y=n41
XU580 XOR2XL $PINS A=B[1] B=B[0] Y=DIFF[1]
XU581 INVX1 $PINS A=n89 Y=n91
XU582 INVX1 $PINS A=n184 Y=n182
XU583 INVX1 $PINS A=n156 Y=n154
XU584 INVX1 $PINS A=n113 Y=n111
XU585 XOR2X2 $PINS A=n77 B=n438 Y=DIFF[29]
XU586 XOR2X2 $PINS A=n99 B=n440 Y=DIFF[27]
XU587 OAI21XL $PINS A0=n83 A1=n73 B0=n76 Y=n72
XU589 XNOR2X1 $PINS A=n197 B=n25 Y=DIFF[11]
XU590 NAND2XL $PINS A=n443 B=n191 Y=n24
XU591 XOR2X1 $PINS A=n30 B=n224 Y=DIFF[6]
XU592 NAND2XL $PINS A=n45 B=n48 Y=n3
XU593 INVXL $PINS A=n53 Y=n51
XU594 INVX1 $PINS A=n214 Y=n212
XU595 OR2X2 $PINS A=A[13] B=n296 Y=n444
XU596 OR2X2 $PINS A=n282 B=A[27] Y=n446
XU597 INVX1 $PINS A=n232 Y=n230
XU598 NAND2X1 $PINS A=n280 B=A[29] Y=n76
XU599 NAND2X1 $PINS A=n278 B=A[31] Y=n58
XU600 OR2X2 $PINS A=A[8] B=n301 Y=n450
XU601 XOR2X1 $PINS A=n33 B=n236 Y=DIFF[3]
XU602 XNOR2X1 $PINS A=n35 B=A[35] Y=DIFF[35]
XU603 OAI21XL $PINS A0=n36 A1=n1 B0=n37 Y=n35
XU604 OR2X2 $PINS A=A[10] B=n299 Y=n451
XU605 OR2X2 $PINS A=A[7] B=n302 Y=n452
XU606 INVX1 $PINS A=B[20] Y=n289
XU607 INVX1 $PINS A=B[14] Y=n295
XU608 INVX1 $PINS A=B[13] Y=n296
XU609 INVX1 $PINS A=B[15] Y=n294
XU610 NAND2X1 $PINS A=A[3] B=n306 Y=n235
XU611 AOI21XL $PINS A0=n38 A1=n53 B0=n39 Y=n37
XU612 OAI21XL $PINS A0=n40 A1=n48 B0=n41 Y=n39
XU613 NAND2X1 $PINS A=A[4] B=n305 Y=n232
XU614 XOR2X1 $PINS A=n34 B=n454 Y=DIFF[2]
XU616 INVX1 $PINS A=B[32] Y=n277
XU617 INVX1 $PINS A=B[31] Y=n278
XU618 INVX1 $PINS A=B[7] Y=n302
XU619 INVX1 $PINS A=B[10] Y=n299
XU620 INVX1 $PINS A=B[33] Y=n276
XU621 NAND2X1 $PINS A=n307 B=A[2] Y=n239
XU622 INVX1 $PINS A=B[4] Y=n305
XU623 INVX1 $PINS A=B[34] Y=n275
XU386 OR2X2 $PINS A=A[6] B=n303 Y=n455
XU403 OAI2BB1X2 $PINS A0N=FE_OFN6059_n107 A1N=n456 B0=n79 Y=n77
XU496 AND2X2 $PINS A=n91 B=n84 Y=n456
XU541 NAND2BX1 $PINS AN=A[11] B=B[11] Y=n449
XU625 OAI2BB1X2 $PINS A0N=FE_DBTN161_n100 A1N=n107 B0=n101 Y=n99
XU627 NOR2BX2 $PINS AN=B[30] B=A[30] Y=n66
.ENDS

.SUBCKT CONV_DW01_sub_5 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI DIFF[35] DIFF[34]
+ DIFF[33] DIFF[32] DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO
*.CONNECT DIFF[0] A[0]
*.CONNECT DIFF[1] A[1]
XFE_OFC2135_n72 CLKINVX3 $PINS A=n74 Y=FE_OFN6097_n72
XFE_OFC2134_n72 INVXL $PINS A=n74 Y=FE_OFN6096_n72
XFE_OFC2133_n72 INVX4 $PINS A=n72 Y=n74
XFE_OFC1897_N1601 CLKINVX3 $PINS A=B[17] Y=n277
XFE_OFC1896_N1592 CLKINVX3 $PINS A=B[8] Y=n286
XFE_OFC1895_N1603 CLKINVX3 $PINS A=B[19] Y=n275
XFE_OFC1894_N1587 INVX1 $PINS A=B[3] Y=n291
XFE_OFC1856_N1609 CLKINVX3 $PINS A=B[25] Y=n269
XFE_OFC1811_N1596 INVX1 $PINS A=B[12] Y=n282
XFE_OFC1779_N1599 INVX2 $PINS A=B[15] Y=n279
XFE_OFC1710_N1604 INVX1 $PINS A=B[20] Y=n274
XFE_OFC1696_N1602 INVX1 $PINS A=B[18] Y=n276
XFE_OFC1675_N1611 INVX1 $PINS A=B[27] Y=n267
XFE_OFC1626_N1610 INVX1 $PINS A=B[26] Y=n268
XFE_OFC1600_N1605 INVX1 $PINS A=B[21] Y=n273
XFE_OFC1599_N1606 INVX1 $PINS A=B[22] Y=n272
XFE_OFC1598_n69 INVXL $PINS A=n69 Y=n67
XFE_OFC1595_N1598 INVX1 $PINS A=B[14] Y=n280
XFE_OFC1553_N1600 CLKINVX3 $PINS A=B[16] Y=n278
XFE_OFC1516_n55 INVX1 $PINS A=n55 Y=n434
XFE_OFC1491_N1617 INVX4 $PINS A=B[33] Y=n261
XFE_OFC640_N1613 CLKINVX3 $PINS A=B[29] Y=n265
XU4 XNOR2X4 $PINS A=n43 B=n2 Y=DIFF[33]
XU14 NOR2X2 $PINS A=A[33] B=n261 Y=n41
XU16 XNOR2X4 $PINS A=n52 B=n3 Y=DIFF[32]
XU26 NOR2X4 $PINS A=A[32] B=n262 Y=n48
XU36 NOR2X2 $PINS A=n68 B=n61 Y=n55
XU40 NOR2X2 $PINS A=A[31] B=n263 Y=n61
XU58 NAND2X2 $PINS A=n77 B=n91 Y=n71
XU59 AOI21X2 $PINS A0=n77 A1=n92 B0=n78 Y=n72
XU64 NOR2X2 $PINS A=A[29] B=n265 Y=n79
XU74 NOR2X2 $PINS A=A[28] B=n266 Y=n86
XU85 OAI21X4 $PINS A0=n97 A1=n101 B0=n98 Y=n92
XU88 NOR2X4 $PINS A=A[27] B=n267 Y=n97
XU95 NAND2X4 $PINS A=A[26] B=n268 Y=n101
XU96 XOR2X4 $PINS A=n110 B=n10 Y=DIFF[25]
XU101 NOR2X4 $PINS A=n108 B=n113 Y=n106
XU105 NOR2X2 $PINS A=A[25] B=n269 Y=n108
XU107 XOR2X2 $PINS A=n117 B=n11 Y=DIFF[24]
XU115 NOR2X2 $PINS A=A[24] B=n270 Y=n113
XU123 NOR2X4 $PINS A=n124 B=n129 Y=n118
XU124 OAI21X4 $PINS A0=n124 A1=n130 B0=n125 Y=n119
XU127 NOR2X2 $PINS A=A[23] B=n271 Y=n124
XU135 NOR2X2 $PINS A=A[22] B=n272 Y=n129
XU136 NAND2X2 $PINS A=A[22] B=n272 Y=n130
XU139 AOI21X4 $PINS A0=n141 A1=n133 B0=n134 Y=n132
XU150 NOR2X2 $PINS A=A[20] B=n274 Y=n138
XU173 AOI21X4 $PINS A0=n155 A1=n163 B0=n156 Y=n154
XU178 NOR2X2 $PINS A=A[17] B=n277 Y=n157
XU190 AOI21X4 $PINS A0=n421 A1=n172 B0=n167 Y=n165
XU204 NAND2X1 $PINS A=A[14] B=n280 Y=n174
XU207 AOI21X4 $PINS A0=n177 A1=n185 B0=n178 Y=n176
XU212 NOR2X2 $PINS A=A[13] B=n281 Y=n179
XU219 NAND2X1 $PINS A=A[12] B=n282 Y=n183
XU222 OAI21X4 $PINS A0=n186 A1=n198 B0=n187 Y=n185
XU241 AOI21X4 $PINS A0=n199 A1=n207 B0=n200 Y=n198
XU242 NOR2X2 $PINS A=n201 B=n204 Y=n199
XU243 OAI21X2 $PINS A0=n201 A1=n205 B0=n202 Y=n200
XU252 NOR2X2 $PINS A=A[8] B=n286 Y=n204
XU253 NAND2X2 $PINS A=A[8] B=n286 Y=n205
XU330 AOI21X4 $PINS A0=n106 A1=n119 B0=n107 Y=n105
XU331 NAND2BX1 $PINS AN=n48 B=n51 Y=n3
XU332 NAND2X1 $PINS A=A[29] B=n265 Y=n80
XU334 NAND2BXL $PINS AN=n108 B=n109 Y=n10
XU335 OAI21X2 $PINS A0=n116 A1=n108 B0=n109 Y=n107
XU336 OAI2BB1X1 $PINS A0N=n185 A1N=n251 B0=n183 Y=n181
XU337 INVX1 $PINS A=n185 Y=n184
XU338 NAND2BXL $PINS AN=n135 B=n136 Y=n14
XU340 NAND2X1 $PINS A=A[7] B=n287 Y=n209
XU341 AOI21X4 $PINS A0=n153 A1=n420 B0=n150 Y=n148
XU342 CLKINVX3 $PINS A=n152 Y=n150
XU343 NAND2X2 $PINS A=A[16] B=n278 Y=n161
XU345 XNOR2X2 $PINS A=n131 B=n13 Y=DIFF[22]
XU346 CLKINVX3 $PINS A=n176 Y=n175
XU347 AOI21X2 $PINS A0=n430 A1=n215 B0=n212 Y=n210
XU348 INVX1 $PINS A=n214 Y=n212
XU349 NAND2BX1 $PINS AN=n201 B=n202 Y=n26
XU350 NAND2X1 $PINS A=n241 B=n130 Y=n13
XU351 INVX1 $PINS A=n129 Y=n241
XU352 NAND2X1 $PINS A=A[33] B=n261 Y=n42
XU354 AOI21X2 $PINS A0=n150 A1=n423 B0=n145 Y=n143
XU355 NAND2X1 $PINS A=A[25] B=n269 Y=n109
XU356 OAI21X4 $PINS A0=n102 A1=n71 B0=FE_OFN6097_n72 Y=n70
XU357 NAND2X1 $PINS A=A[30] B=n264 Y=n69
XU358 NOR2X1 $PINS A=A[30] B=n264 Y=n68
XU359 INVX2 $PINS A=B[30] Y=n264
XU360 NAND2X2 $PINS A=n276 B=A[18] Y=n152
XU362 INVX1 $PINS A=B[11] Y=n283
XU365 INVX1 $PINS A=n196 Y=n194
XU367 NAND2X1 $PINS A=A[24] B=n270 Y=n116
XU368 INVX2 $PINS A=n68 Y=n66
XU369 NAND2X1 $PINS A=A[31] B=n263 Y=n62
XU370 INVX1 $PINS A=n147 Y=n145
XU371 NAND2X1 $PINS A=A[20] B=n274 Y=n139
XU372 NOR2X1 $PINS A=n71 B=n37 Y=n35
XU373 NOR2BX1 $PINS AN=n101 B=n100 Y=n419
XU374 OAI21X4 $PINS A0=n132 A1=n104 B0=n105 Y=n103
XU375 NAND2BX1 $PINS AN=n61 B=n62 Y=n417
XU376 OAI21X2 $PINS A0=n162 A1=n160 B0=n161 Y=n159
XU377 XNOR2X2 $PINS A=n141 B=n15 Y=DIFF[20]
XU378 NAND2BX1 $PINS AN=n160 B=n161 Y=n19
XU379 OAI2BB1X1 $PINS A0N=n141 A1N=n243 B0=n139 Y=n137
XU380 INVX1 $PINS A=n138 Y=n243
XU381 OAI21X1 $PINS A0=FE_OFN6096_n72 A1=n37 B0=n38 Y=n36
XU383 NAND2BX1 $PINS AN=n124 B=n125 Y=n12
XU384 AOI21X2 $PINS A0=n175 A1=n422 B0=n172 Y=n170
XU385 AOI21X1 $PINS A0=n84 A1=n92 B0=n85 Y=n83
XU386 INVX1 $PINS A=n86 Y=n84
XU387 NAND2BX1 $PINS AN=n216 B=n217 Y=n30
XU388 OR2X2 $PINS A=n41 B=n405 Y=n2
XU389 INVX1 $PINS A=n42 Y=n405
XU390 NOR2BX1 $PINS AN=n180 B=n179 Y=n424
XU391 AOI21X1 $PINS A0=n74 A1=n55 B0=n56 Y=n54
XU393 OAI21X4 $PINS A0=n102 A1=n82 B0=n83 Y=n81
XU394 INVX2 $PINS A=n174 Y=n172
XU395 XOR2X2 $PINS A=n181 B=n424 Y=DIFF[13]
XU396 NAND2BX1 $PINS AN=n204 B=n205 Y=n27
XU397 AOI21X1 $PINS A0=n39 A1=n56 B0=n40 Y=n38
XU398 NAND2X1 $PINS A=n73 B=n46 Y=n44
XU399 INVX1 $PINS A=n71 Y=n73
XU400 XNOR2X2 $PINS A=n192 B=n426 Y=DIFF[11]
XU401 NAND2BX1 $PINS AN=n208 B=n209 Y=n28
XU402 NAND2BX1 $PINS AN=n97 B=n98 Y=n413
XU403 INVX1 $PINS A=n182 Y=n251
XU404 NAND2X1 $PINS A=A[28] B=n266 Y=n87
XU406 INVX1 $PINS A=n119 Y=n121
XU407 NAND2X1 $PINS A=n427 B=n428 Y=n186
XU408 NAND2X2 $PINS A=A[10] B=n284 Y=n196
XU409 XOR2X4 $PINS A=n34 B=A[34] Y=DIFF[34]
XU410 AOI21X2 $PINS A0=n197 A1=n428 B0=n194 Y=n192
XU411 NOR2X2 $PINS A=n179 B=n182 Y=n177
XU412 NOR2X2 $PINS A=n157 B=n160 Y=n155
XU413 XNOR2X2 $PINS A=n184 B=n415 Y=DIFF[12]
XU414 INVX1 $PINS A=n207 Y=n206
XU415 OR2X2 $PINS A=A[19] B=n275 Y=n423
XU416 NAND2X1 $PINS A=n423 B=n147 Y=n16
XU418 OAI21X2 $PINS A0=n157 A1=n161 B0=n158 Y=n156
XU419 OAI21X2 $PINS A0=n183 A1=n179 B0=n180 Y=n178
XU420 OAI21XL $PINS A0=n58 A1=n48 B0=n51 Y=n47
XU421 INVX1 $PINS A=n56 Y=n58
XU422 NOR2X1 $PINS A=n48 B=n41 Y=n39
XU424 XOR2X2 $PINS A=n126 B=n12 Y=DIFF[23]
XU425 CLKINVX3 $PINS A=n198 Y=n197
XU426 NAND2X1 $PINS A=A[13] B=n281 Y=n180
XU427 OAI21X2 $PINS A0=n135 A1=n139 B0=n136 Y=n134
XU428 NAND2X1 $PINS A=A[21] B=n273 Y=n136
XU429 XNOR2X4 $PINS A=n88 B=n7 Y=DIFF[28]
XU430 NOR2X4 $PINS A=A[16] B=n278 Y=n160
XU431 OAI21X4 $PINS A0=n210 A1=n208 B0=n209 Y=n207
XU432 NOR2X2 $PINS A=A[26] B=n268 Y=n100
XU433 XNOR2X2 $PINS A=n203 B=n26 Y=DIFF[9]
XU434 OAI21X2 $PINS A0=n206 A1=n204 B0=n205 Y=n203
XU435 AOI21X2 $PINS A0=n46 A1=n74 B0=n47 Y=n45
XU436 INVX1 $PINS A=B[13] Y=n281
XU437 NAND2X1 $PINS A=A[6] B=n288 Y=n214
XU438 OAI21X1 $PINS A0=n216 A1=n218 B0=n217 Y=n215
XU439 OR2X2 $PINS A=A[6] B=n288 Y=n430
XU442 NOR2X1 $PINS A=A[5] B=n289 Y=n216
XU444 NOR2X1 $PINS A=A[7] B=n287 Y=n208
XU445 NAND2X1 $PINS A=A[3] B=n291 Y=n228
XU447 XOR2X2 $PINS A=n162 B=n19 Y=DIFF[16]
XU448 INVX2 $PINS A=n154 Y=n153
XU449 NAND2X1 $PINS A=n239 B=n116 Y=n11
XU450 XOR2X2 $PINS A=n197 B=n425 Y=DIFF[10]
XU451 NAND2X1 $PINS A=n243 B=n139 Y=n15
XU452 INVX1 $PINS A=n191 Y=n189
XU453 XOR2X4 $PINS A=n148 B=n16 Y=DIFF[19]
XU454 NOR2X1 $PINS A=A[12] B=n282 Y=n182
XU455 NAND2X1 $PINS A=n421 B=n422 Y=n164
XU456 OAI21X4 $PINS A0=n102 A1=n89 B0=n90 Y=n88
XU457 XNOR2X4 $PINS A=n99 B=n413 Y=DIFF[27]
XU458 XOR2X2 $PINS A=n206 B=n27 Y=DIFF[8]
XU459 XNOR2X2 $PINS A=n137 B=n14 Y=DIFF[21]
XU460 XNOR2X4 $PINS A=n63 B=n417 Y=DIFF[31]
XU461 INVX4 $PINS A=n163 Y=n162
XU462 XOR2X4 $PINS A=n159 B=n414 Y=DIFF[17]
XU465 INVX1 $PINS A=B[10] Y=n284
XU466 INVX1 $PINS A=B[9] Y=n285
XU467 INVX1 $PINS A=B[24] Y=n270
XU470 INVX1 $PINS A=B[23] Y=n271
XU471 INVX1 $PINS A=n229 Y=n1
XU472 INVX2 $PINS A=B[28] Y=n266
XU473 NOR2X1 $PINS A=n135 B=n138 Y=n133
XU474 XOR2X2 $PINS A=n416 B=n215 Y=DIFF[6]
XU475 INVX1 $PINS A=n113 Y=n239
XU476 OAI21XL $PINS A0=n121 A1=n113 B0=n116 Y=n112
XU477 AND2X2 $PINS A=n422 B=n174 Y=n418
XU479 NAND2X1 $PINS A=n73 B=n66 Y=n64
XU480 AND2X2 $PINS A=n251 B=n183 Y=n415
XU481 OAI21X4 $PINS A0=n102 A1=n100 B0=n101 Y=n99
XU482 OAI21XL $PINS A0=n41 A1=n51 B0=n42 Y=n40
XU483 AOI21X4 $PINS A0=n131 A1=n118 B0=n119 Y=n117
XU484 NAND2X2 $PINS A=A[32] B=n262 Y=n51
XU485 OAI21X2 $PINS A0=n53 A1=n102 B0=n54 Y=n52
XU486 OAI21X2 $PINS A0=n64 A1=n102 B0=n65 Y=n63
XU487 INVX1 $PINS A=n169 Y=n167
XU488 XOR2X4 $PINS A=n81 B=n407 Y=DIFF[29]
XU489 AND2X2 $PINS A=n234 B=n80 Y=n407
XU491 XOR2X4 $PINS A=n175 B=n418 Y=DIFF[14]
XU493 AOI21X2 $PINS A0=n131 A1=n241 B0=n128 Y=n126
XU494 OR2X1 $PINS A=A[17] B=n277 Y=n408
XU495 XOR2X2 $PINS A=n28 B=n210 Y=DIFF[7]
XU496 NAND2X2 $PINS A=n66 B=n69 Y=n5
XU497 XNOR2X4 $PINS A=n70 B=n5 Y=DIFF[30]
XU498 NOR2BX1 $PINS AN=n55 B=n48 Y=n46
XU499 OAI21X4 $PINS A0=n44 A1=n102 B0=n45 Y=n43
XU500 NAND2X1 $PINS A=n73 B=n55 Y=n53
XU501 AND2X2 $PINS A=n420 B=n152 Y=n412
XU502 AOI21X1 $PINS A0=n431 A1=n429 B0=n220 Y=n218
XU503 NAND2X1 $PINS A=n420 B=n423 Y=n142
XU504 NOR2BX1 $PINS AN=n118 B=n113 Y=n111
XU505 NAND2X4 $PINS A=n118 B=n106 Y=n104
XU506 AOI21X2 $PINS A0=n131 A1=n111 B0=n112 Y=n110
XU507 OR2X4 $PINS A=A[18] B=n276 Y=n420
XU508 OAI21X1 $PINS A0=n79 A1=n87 B0=n80 Y=n78
XU509 OR2X4 $PINS A=A[10] B=n284 Y=n428
XU510 AOI21X2 $PINS A0=n427 A1=n194 B0=n189 Y=n187
XU511 CLKINVX3 $PINS A=B[31] Y=n263
XU512 INVX2 $PINS A=B[32] Y=n262
XU513 NOR2X2 $PINS A=n97 B=n100 Y=n91
XU514 AOI21X4 $PINS A0=n35 A1=n103 B0=n36 Y=n34
XU515 NAND2X1 $PINS A=n91 B=n84 Y=n82
XU516 NOR2X2 $PINS A=A[21] B=n273 Y=n135
XU517 NAND2X1 $PINS A=A[19] B=n275 Y=n147
XU518 OAI21X1 $PINS A0=n61 A1=n69 B0=n62 Y=n56
XU519 NAND2X1 $PINS A=A[17] B=n277 Y=n158
XU520 NAND2X1 $PINS A=A[9] B=n285 Y=n202
XU521 NAND2X1 $PINS A=A[15] B=n279 Y=n169
XU522 NOR2X2 $PINS A=A[9] B=n285 Y=n201
XU523 AND2X2 $PINS A=n430 B=n214 Y=n416
XU524 XOR2X2 $PINS A=n153 B=n412 Y=DIFF[18]
XU525 AND2X2 $PINS A=n408 B=n158 Y=n414
XU526 NAND2X1 $PINS A=A[5] B=n289 Y=n217
XU527 INVX1 $PINS A=n91 Y=n89
XU528 OAI21X4 $PINS A0=n164 A1=n176 B0=n165 Y=n163
XU529 AND2X1 $PINS A=n427 B=n191 Y=n426
XU530 INVXL $PINS A=n92 Y=n90
XU531 NAND2XL $PINS A=n84 B=n87 Y=n7
XU532 NOR2X2 $PINS A=n86 B=n79 Y=n77
XU533 XNOR2X4 $PINS A=n102 B=n419 Y=DIFF[26]
XU534 OR2X4 $PINS A=A[15] B=n279 Y=n421
XU535 OR2X4 $PINS A=A[14] B=n280 Y=n422
XU536 NAND2X2 $PINS A=A[27] B=n267 Y=n98
XU537 AOI21X1 $PINS A0=n74 A1=n66 B0=n67 Y=n65
XU539 INVXL $PINS A=n87 Y=n85
XU540 AND2X2 $PINS A=n428 B=n196 Y=n425
XU541 INVXL $PINS A=n79 Y=n234
XU542 INVXL $PINS A=n130 Y=n128
XU543 OR2X2 $PINS A=A[11] B=n283 Y=n427
XU544 NAND2X1 $PINS A=A[23] B=n271 Y=n125
XU545 NAND2X1 $PINS A=A[11] B=n283 Y=n191
XU546 INVX1 $PINS A=n222 Y=n220
XU547 OAI2BB1X1 $PINS A0N=n432 A1N=n1 B0=n228 Y=n429
XU548 XNOR2X1 $PINS A=n31 B=n429 Y=DIFF[4]
XU549 NAND2X1 $PINS A=n431 B=n222 Y=n31
XU550 XOR2X1 $PINS A=n32 B=n229 Y=DIFF[3]
XU551 NAND2X1 $PINS A=n432 B=n228 Y=n32
XU552 NOR2X1 $PINS A=A[2] B=B[2] Y=n229
XU553 NAND2X1 $PINS A=A[4] B=n290 Y=n222
XU554 XNOR2X1 $PINS A=A[2] B=B[2] Y=DIFF[2]
XU555 XOR2X1 $PINS A=n30 B=n218 Y=DIFF[5]
XU556 OR2X2 $PINS A=A[4] B=n290 Y=n431
XU557 OR2X2 $PINS A=A[3] B=n291 Y=n432
XU559 INVX1 $PINS A=B[7] Y=n287
XU560 OR2X4 $PINS A=n34 B=A[34] Y=DIFF[35]
XU562 INVX1 $PINS A=B[4] Y=n290
XU563 INVX1 $PINS A=B[6] Y=n288
XU565 INVX1 $PINS A=B[5] Y=n289
XU566 NAND2BX1 $PINS AN=n434 B=n39 Y=n37
XU567 OAI21X4 $PINS A0=n142 A1=n154 B0=n143 Y=n141
XU568 INVX4 $PINS A=n132 Y=n131
XU569 INVX8 $PINS A=n103 Y=n102
XU382 XNOR2X4 $PINS A=n170 B=n435 Y=DIFF[15]
XU423 AND2X2 $PINS A=n421 B=n169 Y=n435
.ENDS

.SUBCKT CONV_DW01_add_13 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
*.CONNECT SUM[0] B[0]
XFE_RC_648_0 OAI2BB2X2 $PINS A0N=n26 A1N=n267 B0=n267 B1=n26 Y=SUM[8]
XFE_OFC2148_n290 INVX1 $PINS A=n289 Y=FE_OFN6102_n290
XFE_OFC2147_n290 INVX1 $PINS A=n290 Y=n289
XFE_OFC1807_n205 BUFX3 $PINS A=FE_DBTN1188_n205 Y=FE_OFN5892_n205
XFE_OFC1806_n205 INVX1 $PINS A=FE_DBTN1188_n205 Y=FE_OFN5891_n205
XFE_OFC1805_n205 INVX8 $PINS A=n205 Y=FE_DBTN1188_n205
XFE_OFC1397_n258 INVX1 $PINS A=n258 Y=n453
XFE_OFC1391_n202 INVX1 $PINS A=n202 Y=n200
XFE_OFC971_n138 INVX8 $PINS A=n138 Y=n136
XFE_OFC157_n98 INVX1 $PINS A=n98 Y=FE_DBTN160_n98
XFE_DBTC159_n281 CLKINVX3 $PINS A=n281 Y=FE_DBTN159_n281
XU18 XOR2X4 $PINS A=n57 B=n2 Y=SUM[32]
XU60 NOR2X4 $PINS A=A[30] B=B[30] Y=n79
XU74 XOR2X4 $PINS A=n103 B=n6 Y=SUM[28]
XU82 NAND2X2 $PINS A=n121 B=n99 Y=n97
XU83 AOI21X2 $PINS A0=n99 A1=n122 B0=n100 Y=n98
XU84 NOR2X2 $PINS A=n110 B=n101 Y=n99
XU88 NOR2X2 $PINS A=A[28] B=B[28] Y=n101
XU112 NOR2X2 $PINS A=n130 B=n123 Y=n121
XU113 OAI21X1 $PINS A0=n123 A1=n131 B0=n124 Y=n122
XU116 NOR2X2 $PINS A=A[26] B=B[26] Y=n123
XU126 NOR2X2 $PINS A=A[25] B=B[25] Y=n130
XU132 INVX2 $PINS A=n137 Y=n135
XU134 NOR2X4 $PINS A=n177 B=n139 Y=n137
XU135 OAI21X4 $PINS A0=n139 A1=n178 B0=n140 Y=n138
XU136 NAND2X4 $PINS A=n159 B=n141 Y=n139
XU137 AOI21X2 $PINS A0=n141 A1=n160 B0=n142 Y=n140
XU138 NOR2X4 $PINS A=n150 B=n143 Y=n141
XU142 NOR2X4 $PINS A=A[24] B=B[24] Y=n143
XU144 XOR2X4 $PINS A=n152 B=n11 Y=SUM[23]
XU159 AOI21X4 $PINS A0=n176 A1=n159 B0=n160 Y=n156
XU162 NOR2X4 $PINS A=n168 B=n161 Y=n159
XU163 OAI21X4 $PINS A0=n169 A1=n161 B0=n162 Y=n160
XU166 NOR2X4 $PINS A=A[22] B=B[22] Y=n161
XU168 XOR2X4 $PINS A=n170 B=n13 Y=SUM[21]
XU178 XOR2X4 $PINS A=n183 B=n14 Y=SUM[20]
XU187 AOI21X4 $PINS A0=n179 A1=n196 B0=n180 Y=n178
XU188 NOR2X2 $PINS A=n181 B=n188 Y=n179
XU192 NOR2X4 $PINS A=A[20] B=B[20] Y=n181
XU223 NAND2X2 $PINS A=A[17] B=B[17] Y=n203
XU230 AOI21X4 $PINS A0=n225 A1=n210 B0=n211 Y=n209
XU235 NOR2X4 $PINS A=A[16] B=B[16] Y=n212
XU251 NOR2X2 $PINS A=n231 B=n226 Y=n224
XU255 NOR2X4 $PINS A=B[14] B=A[14] Y=n226
XU277 NOR2X2 $PINS A=A[12] B=B[12] Y=n242
XU308 NOR2X2 $PINS A=n268 B=n265 Y=n263
XU366 XOR2X4 $PINS A=n214 B=n18 Y=SUM[16]
XU367 AOI21X4 $PINS A0=n219 A1=n215 B0=n216 Y=n214
XU368 INVX1 $PINS A=n247 Y=n245
XU371 AOI21X4 $PINS A0=n206 A1=n260 B0=n207 Y=n205
XU372 XOR2X2 $PINS A=n244 B=n22 Y=SUM[12]
XU373 AOI21X4 $PINS A0=FE_DBTN1188_n205 A1=n164 B0=n165 Y=n163
XU374 XOR2X4 $PINS A=n81 B=n470 Y=SUM[30]
XU375 AOI21X2 $PINS A0=n82 A1=FE_OFN5892_n205 B0=n83 Y=n81
XU376 OAI21XL $PINS A0=n136 A1=n84 B0=n85 Y=n83
XU378 NAND2X1 $PINS A=A[28] B=B[28] Y=n102
XU380 NAND2X1 $PINS A=FE_DBTN160_n98 B=n442 Y=n443
XU381 NAND2X1 $PINS A=n443 B=n52 Y=n50
XU383 INVX1 $PINS A=n51 Y=n442
XU384 NAND2X1 $PINS A=n77 B=n53 Y=n51
XU385 NAND2X2 $PINS A=FE_DBTN159_n281 B=n445 Y=n446
XU386 NAND2X4 $PINS A=n446 B=n262 Y=n260
XU388 INVX1 $PINS A=n261 Y=n445
XU389 NAND2X1 $PINS A=n275 B=n448 Y=n449
XU390 NAND2X1 $PINS A=n447 B=n28 Y=n450
XU391 NAND2X2 $PINS A=n449 B=n450 Y=SUM[6]
XU392 INVX1 $PINS A=n275 Y=n447
XU393 INVX1 $PINS A=n28 Y=n448
XU394 AOI2BB1X1 $PINS A0N=n281 A1N=n278 B0=n277 Y=n275
XU395 NAND2X1 $PINS A=n322 B=n274 Y=n28
XU396 OR2X4 $PINS A=n197 B=n203 Y=n451
XU397 NAND2X4 $PINS A=n451 B=n198 Y=n196
XU398 NAND2X1 $PINS A=n452 B=n453 Y=n454
XU399 NAND2X1 $PINS A=n454 B=n255 Y=n253
XU400 INVX1 $PINS A=n254 Y=n452
XU402 NOR2X2 $PINS A=B[10] B=A[10] Y=n254
XU403 NAND2X1 $PINS A=A[9] B=B[9] Y=n258
XU404 NAND2X1 $PINS A=A[10] B=B[10] Y=n255
XU405 OAI2BB1X2 $PINS A0N=n240 A1N=n253 B0=n462 Y=n461
XU406 INVX1 $PINS A=n253 Y=n251
XU409 INVX1 $PINS A=n217 Y=n215
XU410 NOR2BX1 $PINS AN=n195 B=n188 Y=n184
XU411 NOR2X2 $PINS A=n197 B=n202 Y=n195
XU414 AOI21X1 $PINS A0=FE_DBTN160_n98 A1=n299 B0=n87 Y=n85
XU415 NOR2X2 $PINS A=n238 B=n208 Y=n206
XU416 NOR2X2 $PINS A=A[29] B=B[29] Y=n88
XU418 NOR2X2 $PINS A=A[17] B=B[17] Y=n202
XU419 INVX1 $PINS A=n177 Y=n171
XU420 NOR2X1 $PINS A=A[9] B=B[9] Y=n257
XU421 XOR2X4 $PINS A=n219 B=n474 Y=SUM[15]
XU422 NAND2X1 $PINS A=A[18] B=B[18] Y=n198
XU423 NAND2X1 $PINS A=A[19] B=B[19] Y=n189
XU424 XOR2X2 $PINS A=n41 B=n40 Y=SUM[34]
XU425 AOI2BB1X1 $PINS A0N=n242 A1N=n248 B0=n466 Y=n462
XU426 INVX1 $PINS A=n243 Y=n466
XU427 NOR2X1 $PINS A=n257 B=n254 Y=n252
XU428 NAND2BXL $PINS AN=n168 B=n169 Y=n13
XU429 AOI21X2 $PINS A0=FE_OFN5892_n205 A1=n104 B0=n105 Y=n103
XU430 NAND2BX1 $PINS AN=n101 B=n102 Y=n6
XU431 OAI21X4 $PINS A0=n259 A1=n238 B0=n235 Y=n233
XU432 CLKINVX3 $PINS A=n461 Y=n235
XU433 NAND2BX1 $PINS AN=n55 B=n56 Y=n2
XU434 AOI21X2 $PINS A0=n245 A1=n249 B0=n246 Y=n244
XU435 NAND2BX1 $PINS AN=n66 B=n67 Y=n3
XU436 NAND2BX2 $PINS AN=n177 B=n159 Y=n155
XU437 NAND2BX1 $PINS AN=n226 B=n227 Y=n20
XU438 NAND2BX1 $PINS AN=n242 B=n243 Y=n22
XU439 AOI21X4 $PINS A0=FE_DBTN1188_n205 A1=n200 B0=n201 Y=n199
XU441 NOR2BX1 $PINS AN=n162 B=n161 Y=n476
XU442 XOR2X4 $PINS A=n233 B=n469 Y=SUM[13]
XU443 AOI21X2 $PINS A0=n461 A1=n224 B0=n225 Y=n221
XU444 NAND2BX1 $PINS AN=n268 B=n269 Y=n27
XU445 NAND2BX1 $PINS AN=n79 B=n80 Y=n470
XU446 NOR2X1 $PINS A=n75 B=n66 Y=n62
XU447 INVX1 $PINS A=n77 Y=n75
XU448 AND2X2 $PINS A=n215 B=n218 Y=n474
XU449 AND2X2 $PINS A=n131 B=n303 Y=n475
XU450 OAI2BB1X2 $PINS A0N=n260 A1N=n252 B0=n251 Y=n249
XU451 OAI21XL $PINS A0=n136 A1=n97 B0=n98 Y=n92
XU452 NAND2BX1 $PINS AN=n287 B=n288 Y=n31
XU453 NAND2BX1 $PINS AN=n181 B=n182 Y=n14
XU454 NAND2BXL $PINS AN=n291 B=n292 Y=n32
XU455 OAI21XL $PINS A0=n270 A1=n268 B0=n269 Y=n267
XU456 NOR2X1 $PINS A=n135 B=n119 Y=n113
XU457 INVX1 $PINS A=n121 Y=n119
XU458 NAND2X1 $PINS A=n95 B=n62 Y=n60
XU459 NAND2BX1 $PINS AN=n265 B=n266 Y=n26
XU460 NAND2BX1 $PINS AN=n257 B=n258 Y=n25
XU461 AOI21X1 $PINS A0=FE_OFN5892_n205 A1=n113 B0=n114 Y=n112
XU462 OAI2BB1X2 $PINS A0N=n457 A1N=n176 B0=n169 Y=n165
XU463 INVX1 $PINS A=n168 Y=n457
XU464 NAND2BX1 $PINS AN=n278 B=n279 Y=n29
XU465 NOR2X1 $PINS A=n155 B=n150 Y=n146
XU467 NAND2BX1 $PINS AN=n254 B=n255 Y=n24
XU468 NAND2BX1 $PINS AN=n123 B=n124 Y=n8
XU469 INVX1 $PINS A=n196 Y=n194
XU470 NOR2X2 $PINS A=A[4] B=B[4] Y=n284
XU471 INVX2 $PINS A=n155 Y=n153
XU472 NAND2X4 $PINS A=n195 B=n179 Y=n177
XU473 AOI21X2 $PINS A0=n91 A1=FE_OFN5892_n205 B0=n92 Y=n90
XU474 XOR2X2 $PINS A=n90 B=n5 Y=SUM[29]
XU475 AND2X2 $PINS A=n200 B=n203 Y=n468
XU476 OAI21X4 $PINS A0=FE_OFN5891_n205 A1=n47 B0=n48 Y=n46
XU477 AOI21X2 $PINS A0=n49 A1=n138 B0=n50 Y=n48
XU478 AOI21XL $PINS A0=n53 A1=n78 B0=n54 Y=n52
XU479 NOR2X1 $PINS A=n66 B=n55 Y=n53
XU480 NOR2X2 $PINS A=n88 B=n79 Y=n77
XU481 NAND2X1 $PINS A=n121 B=n301 Y=n106
XU482 AOI21X2 $PINS A0=n46 A1=n42 B0=n43 Y=n41
XU484 NOR2X1 $PINS A=A[6] B=B[6] Y=n273
XU485 NAND2X1 $PINS A=A[6] B=B[6] Y=n274
XU486 NAND2X1 $PINS A=A[14] B=B[14] Y=n227
XU487 NAND2X2 $PINS A=A[13] B=B[13] Y=n232
XU488 NAND2X1 $PINS A=A[29] B=B[29] Y=n89
XU489 OAI21XL $PINS A0=n136 A1=n106 B0=n107 Y=n105
XU490 NOR2X1 $PINS A=n177 B=n168 Y=n164
XU491 XNOR2X2 $PINS A=FE_DBTN159_n281 B=n29 Y=SUM[5]
XU492 NAND2X1 $PINS A=A[24] B=B[24] Y=n144
XU493 NAND2X2 $PINS A=A[25] B=B[25] Y=n131
XU494 XOR2X2 $PINS A=n270 B=n27 Y=SUM[7]
XU495 XOR2X2 $PINS A=n286 B=n471 Y=SUM[4]
XU496 OAI21XL $PINS A0=n289 A1=n287 B0=n288 Y=n286
XU497 NOR2X2 $PINS A=A[21] B=B[21] Y=n168
XU498 NOR2X2 $PINS A=A[27] B=B[27] Y=n110
XU499 INVX1 $PINS A=n110 Y=n301
XU500 INVX1 $PINS A=n188 Y=n309
XU501 AOI21X1 $PINS A0=FE_DBTN160_n98 A1=n77 B0=n78 Y=n72
XU503 AOI21X2 $PINS A0=n282 A1=FE_OFN6102_n290 B0=n283 Y=n281
XU505 OAI21X2 $PINS A0=n212 A1=n218 B0=n213 Y=n211
XU506 NOR2X1 $PINS A=n287 B=n284 Y=n282
XU507 AOI21X2 $PINS A0=FE_OFN5892_n205 A1=n137 B0=n138 Y=n132
XU508 NOR2X4 $PINS A=A[23] B=B[23] Y=n150
XU509 XOR2X4 $PINS A=n199 B=n16 Y=SUM[18]
XU510 NAND2X1 $PINS A=n95 B=n299 Y=n84
XU511 XNOR2X2 $PINS A=n256 B=n24 Y=SUM[10]
XU512 NAND2X1 $PINS A=n271 B=n263 Y=n261
XU513 NAND2X1 $PINS A=n252 B=n240 Y=n238
XU514 NAND2X2 $PINS A=A[15] B=B[15] Y=n218
XU515 NOR2X2 $PINS A=n247 B=n242 Y=n240
XU516 AOI21X1 $PINS A0=n122 A1=n301 B0=n109 Y=n107
XU517 NAND2X2 $PINS A=n210 B=n224 Y=n208
XU518 XOR2X4 $PINS A=n190 B=n15 Y=SUM[19]
XU519 NAND2XL $PINS A=n299 B=n89 Y=n5
XU520 OAI21X1 $PINS A0=n79 A1=n89 B0=n80 Y=n78
XU521 NOR2X4 $PINS A=n217 B=n212 Y=n210
XU522 NOR2X4 $PINS A=A[15] B=B[15] Y=n217
XU523 OAI21X2 $PINS A0=n259 A1=n257 B0=n258 Y=n256
XU524 OAI21XL $PINS A0=n136 A1=n119 B0=n116 Y=n114
XU525 AOI21X2 $PINS A0=FE_DBTN1188_n205 A1=n171 B0=n176 Y=n170
XU526 NOR2X1 $PINS A=n97 B=n51 Y=n49
XU527 AOI21X1 $PINS A0=n69 A1=FE_OFN5892_n205 B0=n70 Y=n68
XU529 NOR2X1 $PINS A=A[11] B=B[11] Y=n247
XU530 NAND2X2 $PINS A=n236 B=n224 Y=n220
XU531 NOR2X1 $PINS A=A[2] B=B[2] Y=n291
XU532 NAND2X1 $PINS A=A[2] B=B[2] Y=n292
XU533 NAND2X2 $PINS A=A[11] B=B[11] Y=n248
XU535 NAND2X1 $PINS A=A[3] B=B[3] Y=n288
XU537 NAND2X1 $PINS A=A[20] B=B[20] Y=n182
XU538 NAND2X2 $PINS A=A[21] B=B[21] Y=n169
XU539 NOR2X1 $PINS A=n135 B=n97 Y=n91
XU540 NOR2X2 $PINS A=A[32] B=B[32] Y=n55
XU541 INVX1 $PINS A=n197 Y=n310
XU542 NAND2X1 $PINS A=n149 B=n151 Y=n11
XU543 NAND2X1 $PINS A=n463 B=n144 Y=n10
XU544 INVX1 $PINS A=n130 Y=n303
XU545 XOR2X4 $PINS A=n112 B=n7 Y=SUM[27]
XU546 NAND2X1 $PINS A=n301 B=n111 Y=n7
XU548 NAND2X1 $PINS A=n137 B=n49 Y=n47
XU549 NAND2X1 $PINS A=n95 B=n77 Y=n71
XU550 OAI21XL $PINS A0=n284 A1=n288 B0=n285 Y=n283
XU551 NOR2X1 $PINS A=n135 B=n71 Y=n69
XU552 INVX1 $PINS A=n88 Y=n299
XU553 NOR2X2 $PINS A=A[13] B=B[13] Y=n231
XU554 AND2X2 $PINS A=n42 B=B[34] Y=n459
XU555 INVX1 $PINS A=n78 Y=n76
XU556 OR2X2 $PINS A=A[1] B=B[1] Y=n460
XU557 INVX1 $PINS A=n97 Y=n95
XU558 INVX1 $PINS A=n238 Y=n236
XU559 NOR2X2 $PINS A=A[31] B=B[31] Y=n66
XU560 NAND2X1 $PINS A=A[16] B=B[16] Y=n213
XU561 AOI21X1 $PINS A0=n62 A1=FE_DBTN160_n98 B0=n63 Y=n61
XU562 OAI21X1 $PINS A0=n101 A1=n111 B0=n102 Y=n100
XU563 OAI21XL $PINS A0=n55 A1=n67 B0=n56 Y=n54
XU564 AOI21X2 $PINS A0=FE_DBTN1188_n205 A1=n146 B0=n147 Y=n145
XU565 OAI21X2 $PINS A0=n156 A1=n150 B0=n151 Y=n147
XU566 OAI21XL $PINS A0=n76 A1=n66 B0=n67 Y=n63
XU567 OR2XL $PINS A=A[24] B=B[24] Y=n463
XU568 OAI21X2 $PINS A0=n181 A1=n189 B0=n182 Y=n180
XU569 AOI21X4 $PINS A0=FE_DBTN1188_n205 A1=n153 B0=n154 Y=n152
XU570 INVX2 $PINS A=n156 Y=n154
XU571 OR2XL $PINS A=A[16] B=B[16] Y=n464
XU572 NAND2XL $PINS A=A[32] B=B[32] Y=n56
XU574 XOR2X4 $PINS A=n68 B=n3 Y=SUM[31]
XU575 XOR2X1 $PINS A=n32 B=n294 Y=SUM[2]
XU576 OAI21XL $PINS A0=n265 A1=n269 B0=n266 Y=n264
XU577 AOI21X1 $PINS A0=n46 A1=n459 B0=n472 Y=SUM[35]
XU578 XNOR2X2 $PINS A=n46 B=n1 Y=SUM[33]
XU579 AOI21X1 $PINS A0=FE_DBTN159_n281 A1=n271 B0=n272 Y=n270
XU580 AOI21X4 $PINS A0=FE_DBTN1188_n205 A1=n195 B0=n196 Y=n190
XU582 OAI21XL $PINS A0=n136 A1=n71 B0=n72 Y=n70
XU583 AOI21X2 $PINS A0=FE_OFN5892_n205 A1=n126 B0=n127 Y=n125
XU584 NOR2X1 $PINS A=n135 B=n130 Y=n126
XU585 OAI21X2 $PINS A0=n235 A1=n208 B0=n209 Y=n207
XU586 OAI21XL $PINS A0=n136 A1=n130 B0=n131 Y=n127
XU587 XOR2X2 $PINS A=n259 B=n25 Y=SUM[9]
XU588 NOR2X1 $PINS A=n135 B=n84 Y=n82
XU589 XOR2X4 $PINS A=n125 B=n8 Y=SUM[26]
XU590 NOR2X1 $PINS A=n135 B=n106 Y=n104
XU591 XOR2X4 $PINS A=n145 B=n10 Y=SUM[24]
XU592 NOR2X1 $PINS A=A[3] B=B[3] Y=n287
XU593 XOR2X2 $PINS A=FE_DBTN1188_n205 B=n468 Y=SUM[17]
XU594 AOI21X2 $PINS A0=n58 A1=FE_OFN5892_n205 B0=n59 Y=n57
XU595 OAI21XL $PINS A0=n136 A1=n60 B0=n61 Y=n59
XU596 NOR2X1 $PINS A=n135 B=n60 Y=n58
XU597 NAND2X1 $PINS A=A[8] B=B[8] Y=n266
XU598 NOR2X2 $PINS A=A[8] B=B[8] Y=n265
XU599 NOR2X1 $PINS A=n278 B=n273 Y=n271
XU600 OAI21XL $PINS A0=n291 A1=n294 B0=n292 Y=n290
XU601 OAI21X4 $PINS A0=n259 A1=n220 B0=n221 Y=n219
XU602 OAI21XL $PINS A0=n273 A1=n279 B0=n274 Y=n272
XU603 NAND2X1 $PINS A=A[5] B=B[5] Y=n279
XU604 XOR2X4 $PINS A=n228 B=n20 Y=SUM[14]
XU605 NAND2X1 $PINS A=A[12] B=B[12] Y=n243
XU606 NOR2X1 $PINS A=A[5] B=B[5] Y=n278
XU607 NAND2X2 $PINS A=B[23] B=A[23] Y=n151
XU608 AOI21X4 $PINS A0=n233 A1=n229 B0=n230 Y=n228
XU609 XNOR2X2 $PINS A=n249 B=n23 Y=SUM[11]
XU610 NAND2X1 $PINS A=A[4] B=B[4] Y=n285
XU611 XOR2X2 $PINS A=n289 B=n31 Y=SUM[3]
XU612 AND2X1 $PINS A=n324 B=n285 Y=n471
XU613 NAND2BXL $PINS AN=n44 B=n45 Y=n1
XU614 OAI21X2 $PINS A0=n143 A1=n151 B0=n144 Y=n142
XU615 INVXL $PINS A=n89 Y=n87
XU616 NAND2X1 $PINS A=A[22] B=B[22] Y=n162
XU617 NAND2X1 $PINS A=A[30] B=B[30] Y=n80
XU618 NAND2X1 $PINS A=A[7] B=B[7] Y=n269
XU619 AND2X2 $PINS A=n229 B=n232 Y=n469
XU620 NOR2X2 $PINS A=A[18] B=B[18] Y=n197
XU621 INVX4 $PINS A=n260 Y=n259
XU622 NOR2X2 $PINS A=A[19] B=B[19] Y=n188
XU623 NAND2X1 $PINS A=A[31] B=B[31] Y=n67
XU624 NOR2X2 $PINS A=A[7] B=B[7] Y=n268
XU625 AND2X1 $PINS A=n43 B=B[34] Y=n472
XU626 NAND2XL $PINS A=A[33] B=B[33] Y=n45
XU627 AND2X1 $PINS A=n460 B=n294 Y=SUM[1]
XU628 INVX1 $PINS A=n122 Y=n116
XU629 INVX1 $PINS A=n111 Y=n109
XU630 INVX4 $PINS A=n178 Y=n176
XU631 NAND2X1 $PINS A=A[27] B=B[27] Y=n111
XU632 XNOR2X4 $PINS A=n132 B=n475 Y=SUM[25]
XU633 AOI21X2 $PINS A0=FE_DBTN1188_n205 A1=n184 B0=n185 Y=n183
XU634 NAND2X1 $PINS A=n310 B=n198 Y=n16
XU635 NAND2X1 $PINS A=n309 B=n189 Y=n15
XU636 INVXL $PINS A=n203 Y=n201
XU637 INVX1 $PINS A=n218 Y=n216
XU638 XNOR2X4 $PINS A=n163 B=n476 Y=SUM[22]
XU639 NAND2X1 $PINS A=n464 B=n213 Y=n18
XU640 NAND2X1 $PINS A=n245 B=n248 Y=n23
XU641 NAND2X1 $PINS A=A[26] B=B[26] Y=n124
XU642 INVXL $PINS A=n150 Y=n149
XU643 INVX1 $PINS A=n231 Y=n229
XU644 INVX1 $PINS A=n232 Y=n230
XU645 INVX1 $PINS A=n248 Y=n246
XU646 AOI21X2 $PINS A0=n263 A1=n272 B0=n264 Y=n262
XU648 INVX1 $PINS A=n273 Y=n322
XU649 INVX1 $PINS A=n44 Y=n42
XU650 INVX1 $PINS A=n45 Y=n43
XU651 INVX1 $PINS A=n279 Y=n277
XU652 NOR2X1 $PINS A=A[33] B=B[33] Y=n44
XU653 INVX1 $PINS A=n284 Y=n324
XU654 INVX1 $PINS A=B[34] Y=n40
XU655 NAND2XL $PINS A=A[1] B=B[1] Y=n294
XU412 NAND2BX2 $PINS AN=n477 B=n227 Y=n225
XU417 NOR2X1 $PINS A=n226 B=n232 Y=n477
XU581 OR2X2 $PINS A=n194 B=n188 Y=n479
XU656 NAND2X1 $PINS A=n479 B=n189 Y=n185
.ENDS

.SUBCKT CONV_DW01_add_29 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XFE_RC_509_0 OAI21X4 $PINS A0=n89 A1=n77 B0=n78 Y=n76
XFE_OFC2076_n181 INVX1 $PINS A=n181 Y=n180
XFE_OFC441_n69 CLKINVX3 $PINS A=n69 Y=FE_DBTN158_n69
XFE_DBTC157_n87 CLKINVX3 $PINS A=n87 Y=FE_DBTN157_n87
XU6 XNOR2X4 $PINS A=n47 B=n3 Y=SUM[34]
XU21 OAI21X2 $PINS A0=n56 A1=n52 B0=n53 Y=n51
XU24 NOR2X4 $PINS A=B[33] B=A[33] Y=n52
XU26 XOR2X4 $PINS A=n1 B=n5 Y=SUM[32]
XU30 NOR2X2 $PINS A=B[32] B=A[32] Y=n55
XU31 NAND2X4 $PINS A=B[32] B=A[32] Y=n56
XU34 NOR2X2 $PINS A=n59 B=n62 Y=n57
XU35 OAI21X4 $PINS A0=n63 A1=n59 B0=n60 Y=n58
XU38 NOR2X4 $PINS A=B[31] B=A[31] Y=n59
XU42 NAND2X2 $PINS A=FE_DBTN158_n69 B=n64 Y=n62
XU48 NOR2X4 $PINS A=A[30] B=B[30] Y=n66
XU58 NOR2X1 $PINS A=A[29] B=B[29] Y=n69
XU60 XOR2X4 $PINS A=n83 B=n9 Y=SUM[28]
XU79 XNOR2X4 $PINS A=n94 B=n11 Y=SUM[26]
XU93 NAND2X2 $PINS A=A[25] B=B[25] Y=n96
XU96 OAI21X4 $PINS A0=n111 A1=n99 B0=n100 Y=n98
XU294 INVX1 $PINS A=n190 Y=n189
XU296 INVX1 $PINS A=n128 Y=n127
XU298 INVX4 $PINS A=n89 Y=n88
XU299 AOI21X4 $PINS A0=n76 A1=n57 B0=n58 Y=n1
XU300 OAI2BB1X1 $PINS A0N=n98 A1N=n416 B0=n96 Y=n94
XU301 AOI21X4 $PINS A0=n120 A1=n128 B0=n121 Y=n119
XU302 NAND2X1 $PINS A=n76 B=FE_DBTN158_n69 Y=n371
XU303 NAND2X2 $PINS A=n371 B=n70 Y=n68
XU306 NAND2X2 $PINS A=B[29] B=A[29] Y=n70
XU307 OAI21XL $PINS A0=n189 A1=n187 B0=n188 Y=n186
XU308 NAND2X1 $PINS A=B[8] B=A[8] Y=n188
XU309 NOR2X1 $PINS A=n184 B=n187 Y=n182
XU310 NOR2X1 $PINS A=B[8] B=A[8] Y=n187
XU311 AOI21X1 $PINS A0=n162 A1=n404 B0=n159 Y=n157
XU312 INVX1 $PINS A=n161 Y=n159
XU314 OAI21XL $PINS A0=n207 A1=n209 B0=n208 Y=n206
XU315 NOR2X2 $PINS A=B[19] B=A[19] Y=n125
XU316 INVX1 $PINS A=n115 Y=n113
XU317 INVX1 $PINS A=n197 Y=n195
XU318 NOR2X1 $PINS A=B[9] B=A[9] Y=n184
XU319 NAND2X2 $PINS A=B[30] B=A[30] Y=n67
XU320 XOR2X1 $PINS A=n149 B=n22 Y=SUM[15]
XU321 XOR2X1 $PINS A=n32 B=n201 Y=SUM[5]
XU322 NAND2X1 $PINS A=B[20] B=A[20] Y=n123
XU323 NAND2X2 $PINS A=A[22] B=B[22] Y=n115
XU324 NOR2X2 $PINS A=B[21] B=A[21] Y=n117
XU325 XOR2X1 $PINS A=n34 B=n209 Y=SUM[3]
XU326 AND2X2 $PINS A=n416 B=n96 Y=n394
XU327 AOI21X4 $PINS A0=n116 A1=n407 B0=n113 Y=n111
XU328 OAI21X4 $PINS A0=n119 A1=n117 B0=n118 Y=n116
XU331 NAND2BX1 $PINS AN=n117 B=n118 Y=n16
XU332 AOI21X4 $PINS A0=n64 A1=n72 B0=n65 Y=n63
XU333 INVX1 $PINS A=n70 Y=n72
XU334 NOR2X1 $PINS A=n144 B=n147 Y=n142
XU335 AOI21X2 $PINS A0=n411 A1=FE_DBTN157_n87 B0=n80 Y=n78
XU336 AOI21X2 $PINS A0=n137 A1=n400 B0=n132 Y=n130
XU337 INVX1 $PINS A=n139 Y=n137
XU339 AOI21X1 $PINS A0=n206 A1=n414 B0=n203 Y=n201
XU340 NOR2BX2 $PINS AN=n53 B=n52 Y=n384
XU341 AOI21XL $PINS A0=n389 A1=n405 B0=n137 Y=n135
XU342 INVX4 $PINS A=n141 Y=n389
XU343 NAND2X1 $PINS A=n235 B=n126 Y=n18
XU344 INVX1 $PINS A=n125 Y=n235
XU345 AOI21X2 $PINS A0=n182 A1=n190 B0=n183 Y=n181
XU346 OR2X2 $PINS A=n55 B=n52 Y=n48
XU347 AOI21X1 $PINS A0=n412 A1=n214 B0=n211 Y=n209
XU348 OAI21XL $PINS A0=n149 A1=n147 B0=n148 Y=n146
XU349 AND2X2 $PINS A=n400 B=n134 Y=n392
XU350 AOI21X2 $PINS A0=n88 A1=n409 B0=FE_DBTN157_n87 Y=n83
XU352 OAI21X2 $PINS A0=n75 A1=n62 B0=n63 Y=n61
XU353 NAND2BXL $PINS AN=n122 B=n123 Y=n17
XU354 INVX1 $PINS A=n98 Y=n97
XU355 AOI21X2 $PINS A0=n51 A1=n376 B0=n44 Y=n42
XU356 INVX1 $PINS A=n46 Y=n44
XU357 NAND2BX1 $PINS AN=n144 B=n145 Y=n21
XU358 NAND2BX1 $PINS AN=n215 B=n216 Y=n36
XU359 INVX1 $PINS A=n163 Y=n162
XU360 NAND2X2 $PINS A=n399 B=n403 Y=n169
XU361 NAND2BX2 $PINS AN=n55 B=n56 Y=n5
XU362 NAND2BX2 $PINS AN=n48 B=n376 Y=n41
XU363 NAND2BX1 $PINS AN=n199 B=n200 Y=n32
XU364 NAND2BX1 $PINS AN=n207 B=n208 Y=n34
XU365 NAND2BX1 $PINS AN=n187 B=n188 Y=n29
XU367 OAI21X2 $PINS A0=n48 A1=n1 B0=n49 Y=n47
XU368 INVX1 $PINS A=n51 Y=n49
XU369 NAND2BX1 $PINS AN=n147 B=n148 Y=n22
XU370 XOR2X1 $PINS A=n175 B=n26 Y=SUM[11]
XU371 NAND2BX1 $PINS AN=n191 B=n192 Y=n30
XU372 NAND2BX1 $PINS AN=n184 B=n185 Y=n28
XU373 INVX1 $PINS A=n129 Y=n390
XU374 XOR2X4 $PINS A=n61 B=n372 Y=SUM[31]
XU375 AND2X2 $PINS A=n223 B=n60 Y=n372
XU376 NAND2X1 $PINS A=B[5] B=A[5] Y=n200
XU377 XOR2X2 $PINS A=n119 B=n16 Y=SUM[21]
XU378 NAND2X2 $PINS A=B[13] B=A[13] Y=n161
XU379 NAND2X2 $PINS A=n401 B=n404 Y=n151
XU380 OAI21XL $PINS A0=n184 A1=n188 B0=n185 Y=n183
XU381 NAND2X1 $PINS A=B[28] B=A[28] Y=n82
XU383 NAND2X2 $PINS A=B[27] B=A[27] Y=n87
XU384 NAND2X1 $PINS A=n82 B=n411 Y=n9
XU385 NAND2X2 $PINS A=B[15] B=A[15] Y=n148
XU386 AOI21X1 $PINS A0=n180 A1=n403 B0=n177 Y=n175
XU387 NOR2X1 $PINS A=B[3] B=A[3] Y=n207
XU388 NOR2X1 $PINS A=B[5] B=A[5] Y=n199
XU389 OAI21XL $PINS A0=n201 A1=n199 B0=n200 Y=n198
XU390 OAI21X1 $PINS A0=n193 A1=n191 B0=n192 Y=n190
XU391 OR2X2 $PINS A=B[35] B=A[35] Y=n415
XU392 INVX1 $PINS A=n82 Y=n80
XU393 NAND2X1 $PINS A=A[17] B=B[17] Y=n139
XU394 INVX1 $PINS A=A[17] Y=n382
XU395 INVX1 $PINS A=n150 Y=n149
XU396 INVX1 $PINS A=n205 Y=n203
XU397 NAND2X1 $PINS A=B[6] B=A[6] Y=n197
XU398 OR2X2 $PINS A=B[6] B=A[6] Y=n410
XU399 INVX1 $PINS A=n104 Y=n102
XU400 INVX1 $PINS A=n213 Y=n211
XU401 NAND2X1 $PINS A=B[3] B=A[3] Y=n208
XU402 NAND2X1 $PINS A=B[9] B=A[9] Y=n185
XU404 INVX1 $PINS A=n109 Y=n107
XU405 NAND2X1 $PINS A=B[35] B=A[35] Y=n39
XU406 NAND2BX1 $PINS AN=n92 B=n93 Y=n11
XU407 NAND2X4 $PINS A=n376 B=n46 Y=n3
XU408 INVX1 $PINS A=n167 Y=n165
XU409 INVX1 $PINS A=A[18] Y=n380
XU410 NAND2X1 $PINS A=B[24] B=A[24] Y=n104
XU411 OR2X4 $PINS A=A[27] B=B[27] Y=n383
XU412 AOI21X1 $PINS A0=n198 A1=n410 B0=n195 Y=n193
XU413 NAND2X1 $PINS A=B[11] B=A[11] Y=n174
XU414 XOR2X2 $PINS A=n68 B=n406 Y=SUM[30]
XU415 OAI21XL $PINS A0=n215 A1=n218 B0=n216 Y=n214
XU416 INVX1 $PINS A=n67 Y=n65
XU418 OR2X2 $PINS A=B[12] B=A[12] Y=n408
XU420 NOR2X1 $PINS A=B[7] B=A[7] Y=n191
XU421 XNOR2X1 $PINS A=n146 B=n21 Y=SUM[16]
XU422 XNOR2X1 $PINS A=n135 B=n392 Y=SUM[18]
XU423 NAND2X1 $PINS A=n410 B=n197 Y=n31
XU424 INVX1 $PINS A=n126 Y=n387
XU425 INVX1 $PINS A=n402 Y=n379
XU426 XOR2X1 $PINS A=n127 B=n18 Y=SUM[19]
XU427 XNOR2X1 $PINS A=n33 B=n206 Y=SUM[4]
XU429 OR2X4 $PINS A=B[34] B=A[34] Y=n376
XU430 OR2X2 $PINS A=B[0] B=A[0] Y=n377
XU431 NAND2X1 $PINS A=B[26] B=A[26] Y=n93
XU432 NOR2BX2 $PINS AN=n110 B=n379 Y=n388
XU433 OAI21X4 $PINS A0=n122 A1=n126 B0=n123 Y=n121
XU434 NOR2X2 $PINS A=n122 B=n125 Y=n120
XU435 NAND2BX4 $PINS AN=B[18] B=n380 Y=n400
XU436 NAND2X1 $PINS A=n397 B=n402 Y=n99
XU437 OAI21X4 $PINS A0=n1 A1=n41 B0=n42 Y=n40
XU438 XNOR2X2 $PINS A=n97 B=n394 Y=SUM[25]
XU439 OR2X2 $PINS A=B[10] B=A[10] Y=n403
XU440 XOR2X1 $PINS A=n110 B=n393 Y=SUM[23]
XU441 NAND2BX4 $PINS AN=B[17] B=n382 Y=n405
XU442 AOI21X2 $PINS A0=n397 A1=n107 B0=n102 Y=n100
XU443 OAI21X2 $PINS A0=n92 A1=n96 B0=n93 Y=n91
XU444 INVX1 $PINS A=n156 Y=n154
XU445 INVX1 $PINS A=n59 Y=n223
XU446 NAND2X2 $PINS A=n400 B=n405 Y=n129
XU447 XOR2X4 $PINS A=n54 B=n384 Y=SUM[33]
XU448 NAND2XL $PINS A=n174 B=n399 Y=n26
XU449 AOI21X4 $PINS A0=n401 A1=n159 B0=n154 Y=n152
XU450 OAI21X1 $PINS A0=n144 A1=n148 B0=n145 Y=n143
XU451 NAND2X1 $PINS A=n407 B=n115 Y=n15
XU452 AOI21X4 $PINS A0=n399 A1=n177 B0=n172 Y=n170
XU453 INVX1 $PINS A=n174 Y=n172
XU454 NOR2X2 $PINS A=B[15] B=A[15] Y=n147
XU455 NAND2X2 $PINS A=n389 B=n390 Y=n391
XU456 OR2X4 $PINS A=B[22] B=A[22] Y=n407
XU457 OR2X4 $PINS A=B[14] B=A[14] Y=n401
XU458 NAND2X1 $PINS A=B[10] B=A[10] Y=n179
XU459 OAI21X4 $PINS A0=n181 A1=n169 B0=n170 Y=n168
XU460 NOR2X2 $PINS A=n92 B=n95 Y=n90
XU461 NOR2X4 $PINS A=B[20] B=A[20] Y=n122
XU462 NOR2X4 $PINS A=B[16] B=A[16] Y=n144
XU463 NAND2X2 $PINS A=B[16] B=A[16] Y=n145
XU464 XOR2X4 $PINS A=n75 B=n395 Y=SUM[29]
XU465 NAND2X1 $PINS A=n411 B=n383 Y=n77
XU466 AND2X2 $PINS A=n409 B=n87 Y=n398
XU467 XNOR2X2 $PINS A=n116 B=n15 Y=SUM[22]
XU468 OAI21X4 $PINS A0=n163 A1=n151 B0=n152 Y=n150
XU469 AOI21X4 $PINS A0=n168 A1=n408 B0=n165 Y=n163
XU470 OR2X4 $PINS A=B[24] B=A[24] Y=n397
XU471 AOI21X4 $PINS A0=n98 A1=n90 B0=n91 Y=n89
XU472 XOR2X2 $PINS A=n398 B=n88 Y=SUM[27]
XU473 AOI21X4 $PINS A0=n142 A1=n150 B0=n143 Y=n141
XU474 OR2X2 $PINS A=n386 B=n387 Y=n124
XU475 NAND2X2 $PINS A=B[19] B=A[19] Y=n126
XU476 XNOR2X1 $PINS A=n124 B=n17 Y=SUM[20]
XU477 NAND2X4 $PINS A=n391 B=n130 Y=n128
XU478 NAND2X2 $PINS A=A[21] B=B[21] Y=n118
XU479 NOR2X2 $PINS A=n388 B=n107 Y=n105
XU480 OR2X2 $PINS A=B[23] B=A[23] Y=n402
XU481 INVX4 $PINS A=n111 Y=n110
XU482 XOR2X4 $PINS A=n105 B=n13 Y=SUM[24]
XU483 NAND2X1 $PINS A=B[23] B=A[23] Y=n109
XU484 OR2X4 $PINS A=B[11] B=A[11] Y=n399
XU485 NOR2X1 $PINS A=B[25] B=A[25] Y=n95
XU486 OR2X2 $PINS A=B[4] B=A[4] Y=n414
XU487 INVX1 $PINS A=n179 Y=n177
XU488 OR2X2 $PINS A=B[2] B=A[2] Y=n412
XU489 OAI21X4 $PINS A0=n1 A1=n55 B0=n56 Y=n54
XU490 NAND2X1 $PINS A=B[12] B=A[12] Y=n167
XU491 AND2X1 $PINS A=n377 B=n218 Y=SUM[0]
XU492 AND2X2 $PINS A=n402 B=n109 Y=n393
XU493 NAND2XL $PINS A=n405 B=n139 Y=n20
XU494 NAND2XL $PINS A=n404 B=n161 Y=n24
XU495 NAND2XL $PINS A=n403 B=n179 Y=n27
XU496 XOR2XL $PINS A=n30 B=n193 Y=SUM[7]
XU497 NOR2X2 $PINS A=B[26] B=A[26] Y=n92
XU498 NAND2X1 $PINS A=B[18] B=A[18] Y=n134
XU499 NAND2X1 $PINS A=B[14] B=A[14] Y=n156
XU500 NAND2XL $PINS A=B[7] B=A[7] Y=n192
XU501 NAND2XL $PINS A=n414 B=n205 Y=n33
XU502 NAND2XL $PINS A=B[1] B=A[1] Y=n216
XU503 INVX1 $PINS A=n134 Y=n132
XU504 NAND2XL $PINS A=n397 B=n104 Y=n13
XU505 XNOR2X1 $PINS A=n168 B=n25 Y=SUM[12]
XU506 NAND2X1 $PINS A=n408 B=n167 Y=n25
XU507 XNOR2X1 $PINS A=n389 B=n20 Y=SUM[17]
XU508 XNOR2X1 $PINS A=n162 B=n24 Y=SUM[13]
XU509 XOR2X1 $PINS A=n157 B=n23 Y=SUM[14]
XU510 NAND2X1 $PINS A=n401 B=n156 Y=n23
XU511 XNOR2X1 $PINS A=n180 B=n27 Y=SUM[10]
XU512 XNOR2X1 $PINS A=n31 B=n198 Y=SUM[6]
XU513 AND2X2 $PINS A=n64 B=n67 Y=n406
XU514 OR2X2 $PINS A=A[27] B=B[27] Y=n409
XU515 XNOR2X1 $PINS A=n186 B=n28 Y=SUM[9]
XU516 XOR2X1 $PINS A=n189 B=n29 Y=SUM[8]
XU517 NAND2X2 $PINS A=B[31] B=A[31] Y=n60
XU518 NAND2X2 $PINS A=B[33] B=A[33] Y=n53
XU519 OR2X4 $PINS A=A[28] B=B[28] Y=n411
XU520 NOR2X1 $PINS A=B[1] B=A[1] Y=n215
XU521 NAND2X1 $PINS A=B[2] B=A[2] Y=n213
XU522 XNOR2X1 $PINS A=n35 B=n214 Y=SUM[2]
XU523 NAND2XL $PINS A=n412 B=n213 Y=n35
XU524 NAND2X2 $PINS A=B[34] B=A[34] Y=n46
XU525 XOR2X4 $PINS A=n40 B=n413 Y=SUM[35]
XU526 AND2X2 $PINS A=n415 B=n39 Y=n413
XU527 NAND2X1 $PINS A=B[4] B=A[4] Y=n205
XU528 XOR2X1 $PINS A=n36 B=n218 Y=SUM[1]
XU529 NAND2X1 $PINS A=B[0] B=A[0] Y=n218
XU530 INVX2 $PINS A=n76 Y=n75
XU531 INVX4 $PINS A=n66 Y=n64
XU295 OR2X2 $PINS A=B[25] B=A[25] Y=n416
XU338 AND2X2 $PINS A=n128 B=n235 Y=n386
XU366 NAND2BX2 $PINS AN=B[13] B=n417 Y=n404
XU419 INVX1 $PINS A=A[13] Y=n417
XU428 NAND2BX1 $PINS AN=n69 B=n70 Y=n395
.ENDS

.SUBCKT CONV_DW01_add_30 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO N607 N611
*.CONNECT n35 A[34]
*.CONNECT n38 A[33]
*.CONNECT SUM[0] A[0]
*.CONNECT SUM[1] A[1]
XFE_OFC1597_n192 INVXL $PINS A=n191 Y=FE_OFN5780_n192
XFE_OFC1596_n192 CLKINVX3 $PINS A=n192 Y=n191
XFE_OFC245_N630 INVX1 $PINS A=B[28] Y=n401
XFE_OFC225_n94 INVX1 $PINS A=n94 Y=n400
XU12 XOR2X2 $PINS A=n47 B=n1 Y=SUM[32]
XU32 XOR2X2 $PINS A=n63 B=n3 Y=SUM[30]
XU39 OAI21X1 $PINS A0=n67 A1=n61 B0=n62 Y=n56
XU42 NOR2X1 $PINS A=B[30] B=A[30] Y=n61
XU49 AOI21X2 $PINS A0=n365 A1=n74 B0=n69 Y=n67
XU57 AOI21X4 $PINS A0=n77 A1=n385 B0=n74 Y=n72
XU66 AOI21X4 $PINS A0=n87 A1=n79 B0=n80 Y=n78
XU71 NOR2X1 $PINS A=B[27] B=A[27] Y=n81
XU84 NOR2X2 $PINS A=n97 B=n92 Y=n90
XU88 NOR2X2 $PINS A=B[25] B=A[25] Y=n92
XU110 NOR2X2 $PINS A=B[23] B=A[23] Y=n104
XU122 OAI21X4 $PINS A0=n368 A1=n117 B0=n118 Y=n116
XU125 NOR2X2 $PINS A=B[21] B=A[21] Y=n117
XU188 NOR2X1 $PINS A=A[13] B=B[13] Y=n156
XU289 NAND2X2 $PINS A=B[26] B=A[26] Y=n85
XU290 CLKINVX3 $PINS A=n105 Y=n107
XU291 NOR2X1 $PINS A=n153 B=n156 Y=n151
XU292 AOI21X1 $PINS A0=n77 A1=n55 B0=n56 Y=n54
XU293 NAND2X1 $PINS A=A[7] B=B[7] Y=n198
XU294 OR2X2 $PINS A=A[7] B=B[7] Y=n393
XU295 XNOR2X2 $PINS A=n86 B=n379 Y=SUM[26]
XU297 XOR2X1 $PINS A=n166 B=n21 Y=SUM[12]
XU298 AOI21X1 $PINS A0=n171 A1=n396 B0=n168 Y=n166
XU299 XNOR2X1 $PINS A=n210 B=n28 Y=SUM[5]
XU300 OAI21XL $PINS A0=n213 A1=n211 B0=n212 Y=n210
XU301 AOI21X1 $PINS A0=n218 A1=n398 B0=n215 Y=n213
XU302 NOR2X1 $PINS A=A[10] B=B[10] Y=n175
XU303 AND2X2 $PINS A=n384 B=n396 Y=n371
XU304 NAND2X1 $PINS A=A[2] B=B[2] Y=n220
XU305 NAND2X2 $PINS A=B[19] B=A[19] Y=n126
XU306 OR2X2 $PINS A=A[9] B=N611 Y=n397
XU307 NAND2X1 $PINS A=B[29] B=A[29] Y=n71
XU308 NAND2X1 $PINS A=n365 B=n385 Y=n66
XU309 NAND2X1 $PINS A=n369 B=n157 Y=n155
XU310 NAND2X1 $PINS A=B[23] B=A[23] Y=n105
XU311 NAND2X1 $PINS A=B[25] B=A[25] Y=n93
XU312 NOR2X2 $PINS A=A[24] B=B[24] Y=n97
XU313 XNOR2X1 $PINS A=n159 B=n20 Y=SUM[13]
XU314 NOR2X2 $PINS A=B[26] B=A[26] Y=n84
XU315 NAND2X1 $PINS A=A[31] B=B[31] Y=n53
XU316 XOR2X1 $PINS A=n40 B=n38 Y=SUM[33]
XU317 AND2X2 $PINS A=n40 B=n38 Y=n390
XU318 XOR2X1 $PINS A=n139 B=n16 Y=SUM[17]
XU319 XOR2X2 $PINS A=n12 B=n368 Y=SUM[21]
XU320 NOR2BX1 $PINS AN=n85 B=n84 Y=n379
XU321 AND2X2 $PINS A=n148 B=n238 Y=n375
XU322 XNOR2X1 $PINS A=n172 B=n383 Y=SUM[11]
XU323 AOI21X1 $PINS A0=n149 A1=n238 B0=n146 Y=n144
XU324 INVX1 $PINS A=n147 Y=n238
XU325 NAND2BX1 $PINS AN=n45 B=n46 Y=n1
XU326 NAND2BX1 $PINS AN=n142 B=n143 Y=n17
XU327 NAND2BX1 $PINS AN=n153 B=n154 Y=n19
XU328 OAI21X1 $PINS A0=n191 A1=n185 B0=n186 Y=n184
XU330 NAND2BX1 $PINS AN=n81 B=n82 Y=n6
XU331 OAI2BB1X1 $PINS A0N=n56 A1N=n364 B0=n53 Y=n49
XU332 INVX1 $PINS A=n50 Y=n364
XU333 AOI21X2 $PINS A0=n188 A1=n397 B0=n181 Y=n179
XU334 INVX1 $PINS A=n186 Y=n188
XU335 NAND2BX1 $PINS AN=n156 B=n159 Y=n369
XU336 NAND2XL $PINS A=n398 B=n217 Y=n30
XU337 AOI21X4 $PINS A0=n132 A1=n391 B0=n129 Y=n127
XU338 INVX1 $PINS A=n131 Y=n129
XU339 NAND2BX1 $PINS AN=n61 B=n62 Y=n3
XU340 INVX1 $PINS A=n170 Y=n168
XU341 NAND2BX1 $PINS AN=n175 B=n176 Y=n23
XU342 OAI2BB1X2 $PINS A0N=n371 A1N=n171 B0=n161 Y=n159
XU343 AND2X2 $PINS A=n376 B=n123 Y=n368
XU344 OAI21XL $PINS A0=n53 A1=n45 B0=n46 Y=n44
XU345 NAND2X1 $PINS A=n245 B=n397 Y=n178
XU346 INVX1 $PINS A=n185 Y=n245
XU347 NAND2X1 $PINS A=n230 B=n90 Y=n88
XU348 NAND2BX1 $PINS AN=n211 B=n212 Y=n29
XU349 XOR2X1 $PINS A=n205 B=n27 Y=SUM[6]
XU350 NAND2BX1 $PINS AN=n50 B=n53 Y=n381
XU351 NOR2BX1 $PINS AN=n100 B=n97 Y=n380
XU352 NAND2BX1 $PINS AN=n117 B=n118 Y=n12
XU353 NAND2X1 $PINS A=A[6] B=B[6] Y=n203
XU354 OAI21XL $PINS A0=n81 A1=n85 B0=n82 Y=n80
XU356 XNOR2X1 $PINS A=n13 B=n124 Y=SUM[20]
XU357 XOR2X1 $PINS A=n144 B=n17 Y=SUM[16]
XU358 NOR2BX1 $PINS AN=n55 B=n50 Y=n48
XU359 XNOR2X1 $PINS A=n116 B=n377 Y=SUM[22]
XU360 XNOR2X2 $PINS A=n77 B=n378 Y=SUM[28]
XU361 NAND2X1 $PINS A=A[12] B=B[12] Y=n165
XU362 INVX1 $PINS A=n209 Y=n207
XU363 INVX1 $PINS A=n220 Y=n218
XU364 OAI21XL $PINS A0=n92 A1=n100 B0=n93 Y=n91
XU365 NAND2X1 $PINS A=A[5] B=N607 Y=n209
XU366 OR2X2 $PINS A=A[5] B=N607 Y=n399
XU367 OR2X2 $PINS A=B[18] B=A[18] Y=n391
XU368 AOI21X1 $PINS A0=n384 A1=n168 B0=n163 Y=n161
XU369 NAND2X1 $PINS A=A[10] B=B[10] Y=n176
XU370 INVX1 $PINS A=n183 Y=n181
XU371 INVX1 $PINS A=n66 Y=n64
XU372 NOR2X1 $PINS A=B[31] B=A[31] Y=n50
XU373 INVX1 $PINS A=n71 Y=n69
XU374 NAND2X1 $PINS A=B[22] B=A[22] Y=n115
XU375 CLKINVX3 $PINS A=n104 Y=n230
XU376 NAND2X1 $PINS A=B[32] B=A[32] Y=n46
XU377 NOR2X1 $PINS A=B[32] B=A[32] Y=n45
XU378 NOR2X1 $PINS A=n50 B=n45 Y=n43
XU379 NOR2X1 $PINS A=n84 B=n81 Y=n79
XU380 NOR2X1 $PINS A=n66 B=n61 Y=n55
XU382 NOR2X1 $PINS A=n104 B=n97 Y=n95
XU383 XNOR2X2 $PINS A=n83 B=n6 Y=SUM[27]
XU384 OR2X2 $PINS A=B[29] B=A[29] Y=n365
XU385 INVX2 $PINS A=n172 Y=n171
XU387 NAND2BX1 $PINS AN=n156 B=n157 Y=n20
XU388 XNOR2X1 $PINS A=n177 B=n23 Y=SUM[10]
XU389 CLKINVX3 $PINS A=n150 Y=n149
XU390 NAND2X1 $PINS A=A[14] B=B[14] Y=n154
XU391 NAND2X1 $PINS A=B[17] B=A[17] Y=n138
XU392 NAND2X1 $PINS A=n393 B=n395 Y=n193
XU393 AOI21X1 $PINS A0=n204 A1=n395 B0=n201 Y=n199
XU394 INVX1 $PINS A=n205 Y=n204
XU395 NAND2X2 $PINS A=n389 B=n140 Y=n133
XU396 NAND2X1 $PINS A=A[11] B=B[11] Y=n170
XU397 NOR2X1 $PINS A=A[15] B=B[15] Y=n147
XU398 NAND2X2 $PINS A=A[15] B=B[15] Y=n148
XU399 INVX1 $PINS A=n148 Y=n146
XU400 XOR2X1 $PINS A=n127 B=n14 Y=SUM[19]
XU401 NAND2X1 $PINS A=B[16] B=A[16] Y=n143
XU402 NOR2X2 $PINS A=B[16] B=A[16] Y=n142
XU403 AOI21X1 $PINS A0=n149 A1=n140 B0=n141 Y=n139
XU404 CLKINVX3 $PINS A=n87 Y=n86
XU405 OAI21X4 $PINS A0=n88 A1=n111 B0=n89 Y=n87
XU406 OAI21X1 $PINS A0=n142 A1=n148 B0=n143 Y=n141
XU407 NAND2X1 $PINS A=n384 B=n165 Y=n21
XU408 INVX1 $PINS A=n217 Y=n215
XU409 NAND2X1 $PINS A=n385 B=n76 Y=n378
XU410 XOR2X1 $PINS A=n54 B=n381 Y=SUM[31]
XU411 NOR2X1 $PINS A=n178 B=n175 Y=n173
XU412 OR2X2 $PINS A=A[6] B=B[6] Y=n395
XU413 INVX1 $PINS A=n203 Y=n201
XU415 INVX1 $PINS A=n76 Y=n74
XU416 OR2X2 $PINS A=A[28] B=B[28] Y=n385
XU417 NAND2X1 $PINS A=n399 B=n209 Y=n28
XU418 NAND2X1 $PINS A=n395 B=n203 Y=n27
XU419 OR2X2 $PINS A=B[22] B=A[22] Y=n388
XU420 NAND2BX1 $PINS AN=n125 B=n126 Y=n14
XU421 OAI21XL $PINS A0=n105 A1=n97 B0=n100 Y=n96
XU422 AND2X2 $PINS A=n396 B=n170 Y=n383
XU423 XNOR2X1 $PINS A=n184 B=n24 Y=SUM[9]
XU424 AND2X2 $PINS A=n43 B=n55 Y=n372
XU425 NAND2X1 $PINS A=n392 B=n123 Y=n13
XU426 AND2X2 $PINS A=n230 B=n105 Y=n386
XU427 NAND2X1 $PINS A=A[4] B=B[4] Y=n212
XU428 NAND2X2 $PINS A=A[13] B=B[13] Y=n157
XU429 NAND2X1 $PINS A=B[20] B=A[20] Y=n123
XU430 OR2X2 $PINS A=A[2] B=B[2] Y=n370
XU431 AOI21X2 $PINS A0=n90 A1=n107 B0=n91 Y=n89
XU433 OAI2BB1X2 $PINS A0N=n372 A1N=n77 B0=n42 Y=n40
XU434 AND2X2 $PINS A=n370 B=n220 Y=SUM[2]
XU435 XOR2X2 $PINS A=n149 B=n375 Y=SUM[15]
XU436 NAND2X2 $PINS A=n392 B=n124 Y=n376
XU437 OR2X2 $PINS A=A[11] B=B[11] Y=n396
XU438 OR2X2 $PINS A=A[17] B=B[17] Y=n389
XU439 OAI21X1 $PINS A0=n153 A1=n157 B0=n154 Y=n152
XU440 NOR2X2 $PINS A=A[14] B=B[14] Y=n153
XU441 OAI21X1 $PINS A0=n179 A1=n175 B0=n176 Y=n174
XU442 INVX1 $PINS A=n67 Y=n65
XU443 INVX1 $PINS A=n115 Y=n113
XU444 XNOR2X1 $PINS A=n132 B=n15 Y=SUM[18]
XU445 XOR2X4 $PINS A=n110 B=n386 Y=SUM[23]
XU446 AOI21X2 $PINS A0=n389 A1=n141 B0=n136 Y=n134
XU447 OAI21X4 $PINS A0=n86 A1=n84 B0=n85 Y=n83
XU448 AOI21X2 $PINS A0=n77 A1=n64 B0=n65 Y=n63
XU449 AOI21X4 $PINS A0=n110 A1=n230 B0=n107 Y=n101
XU450 AOI21X2 $PINS A0=n48 A1=n77 B0=n49 Y=n47
XU451 NAND2X1 $PINS A=B[18] B=A[18] Y=n131
XU452 NOR2X1 $PINS A=n147 B=n142 Y=n140
XU453 NAND2X1 $PINS A=A[3] B=B[3] Y=n217
XU454 NOR2X4 $PINS A=B[19] B=A[19] Y=n125
XU455 NAND2X1 $PINS A=A[9] B=N611 Y=n183
XU456 XNOR2X4 $PINS A=n101 B=n380 Y=SUM[24]
XU457 XNOR2X2 $PINS A=n155 B=n19 Y=SUM[14]
XU458 AOI21X2 $PINS A0=n173 A1=FE_OFN5780_n192 B0=n174 Y=n172
XU459 OR2X2 $PINS A=A[3] B=B[3] Y=n398
XU460 AOI21X1 $PINS A0=n95 A1=n110 B0=n96 Y=n94
XU461 OR2X2 $PINS A=B[20] B=A[20] Y=n392
XU462 OAI21X4 $PINS A0=n150 A1=n133 B0=n134 Y=n132
XU463 INVX4 $PINS A=n111 Y=n110
XU464 AOI21X4 $PINS A0=n159 A1=n151 B0=n152 Y=n150
XU465 XOR2X1 $PINS A=n199 B=n26 Y=SUM[7]
XU466 AOI21X1 $PINS A0=n210 A1=n399 B0=n207 Y=n205
XU467 OAI21XL $PINS A0=n191 A1=n178 B0=n179 Y=n177
XU468 NOR2X1 $PINS A=A[8] B=B[8] Y=n185
XU469 XOR2X1 $PINS A=n191 B=n25 Y=SUM[8]
XU470 NOR2X1 $PINS A=A[4] B=B[4] Y=n211
XU471 OAI21X1 $PINS A0=n205 A1=n193 B0=n194 Y=n192
XU472 OR2X2 $PINS A=A[12] B=B[12] Y=n384
XU473 AOI21X1 $PINS A0=n43 A1=n56 B0=n44 Y=n42
XU474 NAND2X1 $PINS A=A[8] B=B[8] Y=n186
XU476 OAI21X4 $PINS A0=n127 A1=n125 B0=n126 Y=n124
XU477 INVX1 $PINS A=n138 Y=n136
XU478 AOI21X4 $PINS A0=n116 A1=n388 B0=n113 Y=n111
XU479 NAND2XL $PINS A=n388 B=n115 Y=n377
XU480 NAND2X1 $PINS A=B[24] B=A[24] Y=n100
XU481 NAND2BXL $PINS AN=n92 B=n93 Y=n8
XU482 AND2X1 $PINS A=n365 B=n71 Y=n387
XU483 AOI21X1 $PINS A0=n393 A1=n201 B0=n196 Y=n194
XU484 INVX1 $PINS A=n198 Y=n196
XU485 INVX1 $PINS A=n165 Y=n163
XU486 NAND2XL $PINS A=n397 B=n183 Y=n24
XU487 NAND2XL $PINS A=n38 B=n35 Y=n34
XU488 XOR2X1 $PINS A=n29 B=n213 Y=SUM[4]
XU489 XNOR2X2 $PINS A=n72 B=n387 Y=SUM[29]
XU490 NAND2X1 $PINS A=n391 B=n131 Y=n15
XU491 NAND2X1 $PINS A=n389 B=n138 Y=n16
XU492 NAND2X2 $PINS A=B[21] B=A[21] Y=n118
XU493 NAND2X1 $PINS A=n393 B=n198 Y=n26
XU494 NAND2X1 $PINS A=B[27] B=A[27] Y=n82
XU495 NAND2X1 $PINS A=B[30] B=A[30] Y=n62
XU496 XOR2X1 $PINS A=n390 B=n35 Y=SUM[34]
XU497 NAND2X1 $PINS A=n245 B=n186 Y=n25
XU498 NOR2BX1 $PINS AN=n40 B=n34 Y=SUM[35]
XU499 XNOR2X1 $PINS A=n30 B=n218 Y=SUM[3]
XU500 INVX8 $PINS A=n78 Y=n77
XU381 XNOR2X2 $PINS A=n400 B=n8 Y=SUM[25]
XU501 NAND2BX1 $PINS AN=n401 B=A[28] Y=n76
.ENDS

.SUBCKT CONV_DW01_add_28 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XFE_RC_645_0 OAI21X4 $PINS A0=n100 A1=n88 B0=n89 Y=n87
XFE_OCPC2316_N1104 BUFX16 $PINS A=B[34] Y=FE_OCPN6220_N1104
XFE_OCPC2315_N1102 BUFX12 $PINS A=B[32] Y=FE_OCPN6219_N1102
XFE_OCPC2313_N1103 BUFX12 $PINS A=B[33] Y=FE_OCPN6217_N1103
XFE_OCPC2272_N1095 BUFX16 $PINS A=B[25] Y=FE_OCPN6184_N1095
XFE_OFC2224_N1088 CLKBUFX8 $PINS A=B[18] Y=FE_OFN6152_N1088
XFE_OFC2185_N1092 BUFX8 $PINS A=B[22] Y=FE_OFN6133_N1092
XFE_OFC2167_N1093 CLKBUFX8 $PINS A=B[23] Y=FE_OFN6115_N1093
XFE_OFC2163_N1096 CLKBUFX8 $PINS A=B[26] Y=FE_OFN6111_N1096
XFE_OFC1982_N1084 BUFX3 $PINS A=B[14] Y=FE_OFN6010_N1084
XFE_OFC1937_N1086 BUFX3 $PINS A=B[16] Y=FE_OFN5964_N1086
XFE_OFC1655_n143 INVX1 $PINS A=n143 Y=n226
XU20 NOR2X4 $PINS A=n52 B=n55 Y=n50
XU21 OAI21X4 $PINS A0=n52 A1=n56 B0=n53 Y=n51
XU24 NOR2X4 $PINS A=A[33] B=FE_OCPN6217_N1103 Y=n52
XU30 NOR2X2 $PINS A=A[32] B=FE_OCPN6219_N1102 Y=n55
XU31 NAND2X4 $PINS A=A[32] B=FE_OCPN6219_N1102 Y=n56
XU33 AOI21X4 $PINS A0=n57 A1=n65 B0=n58 Y=n1
XU35 OAI21X2 $PINS A0=n59 A1=n63 B0=n60 Y=n58
XU38 NOR2X4 $PINS A=A[31] B=B[31] Y=n59
XU44 NOR2X4 $PINS A=A[30] B=B[30] Y=n62
XU48 OAI21X4 $PINS A0=n66 A1=n78 B0=n67 Y=n65
XU50 AOI21X2 $PINS A0=n374 A1=n74 B0=n69 Y=n67
XU64 NAND2X1 $PINS A=A[28] B=B[28] Y=n76
XU67 AOI21X4 $PINS A0=n87 A1=n79 B0=n80 Y=n78
XU68 NOR2X2 $PINS A=n81 B=n84 Y=n79
XU69 OAI21X4 $PINS A0=n81 A1=n85 B0=n82 Y=n80
XU72 NOR2X4 $PINS A=B[27] B=A[27] Y=n81
XU78 NOR2X4 $PINS A=A[26] B=FE_OFN6111_N1096 Y=n84
XU79 NAND2X4 $PINS A=A[26] B=FE_OFN6111_N1096 Y=n85
XU101 AOI21X4 $PINS A0=n101 A1=n365 B0=n102 Y=n100
XU282 INVX1 $PINS A=n52 Y=n209
XU283 INVX1 $PINS A=n114 Y=n116
XU284 NOR2X2 $PINS A=B[12] B=A[12] Y=n160
XU285 NAND2BXL $PINS AN=n103 B=n104 Y=n14
XU286 AOI21X1 $PINS A0=n182 A1=n373 B0=n179 Y=n177
XU287 OR2X2 $PINS A=B[19] B=A[19] Y=n371
XU288 NAND2X1 $PINS A=n366 B=n184 Y=n182
XU289 OAI21XL $PINS A0=n199 A1=n201 B0=n200 Y=n198
XU290 AOI21X1 $PINS A0=n379 A1=n198 B0=n195 Y=n193
XU291 OAI21XL $PINS A0=n191 A1=n193 B0=n192 Y=n190
XU293 NAND2X1 $PINS A=B[15] B=A[15] Y=n149
XU294 NOR2X2 $PINS A=B[15] B=A[15] Y=n148
XU295 NOR2X1 $PINS A=B[8] B=A[8] Y=n175
XU296 OR2X2 $PINS A=n183 B=n185 Y=n366
XU297 AOI21X1 $PINS A0=n377 A1=n190 B0=n187 Y=n185
XU298 INVX1 $PINS A=n189 Y=n187
XU299 XNOR2X1 $PINS A=n77 B=n9 Y=SUM[28]
XU300 INVX1 $PINS A=n181 Y=n179
XU301 XNOR2X1 $PINS A=n99 B=n13 Y=SUM[24]
XU302 NAND2BX1 $PINS AN=n139 B=n140 Y=n20
XU303 OAI21XL $PINS A0=n141 A1=n139 B0=n140 Y=n138
XU304 INVXL $PINS A=n142 Y=n141
XU305 NAND2BX1 $PINS AN=n136 B=n137 Y=n19
XU306 XNOR2X1 $PINS A=n112 B=n15 Y=SUM[22]
XU307 NAND2XL $PINS A=n221 B=n114 Y=n16
XU308 INVX1 $PINS A=n113 Y=n221
XU309 AOI21X2 $PINS A0=n116 A1=n372 B0=n109 Y=n107
XU310 OAI21XL $PINS A0=n119 A1=n113 B0=n114 Y=n112
XU311 NAND2BX1 $PINS AN=n84 B=n85 Y=n11
XU312 OAI21XL $PINS A0=n153 A1=n151 B0=n152 Y=n150
XU313 INVX1 $PINS A=n154 Y=n153
XU314 AOI2BB1X1 $PINS A0N=n133 A1N=n121 B0=n357 Y=n119
XU315 INVX1 $PINS A=n122 Y=n357
XU316 NAND2BXL $PINS AN=n81 B=n82 Y=n10
XU317 NOR2BX1 $PINS AN=n56 B=n55 Y=n363
XU318 AOI21X1 $PINS A0=n132 A1=n371 B0=n129 Y=n127
XU319 INVX1 $PINS A=n133 Y=n132
XU320 INVX2 $PINS A=n131 Y=n129
XU321 AOI21X1 $PINS A0=n99 A1=n370 B0=n96 Y=n94
XU322 INVX2 $PINS A=n98 Y=n96
XU323 OAI21XL $PINS A0=n119 A1=n106 B0=n107 Y=n105
XU324 INVX1 $PINS A=n197 Y=n195
XU325 XOR2X1 $PINS A=n72 B=n8 Y=SUM[29]
XU326 NAND2BX1 $PINS AN=n59 B=n60 Y=n6
XU327 INVX2 $PINS A=n50 Y=n48
XU328 XOR2X1 $PINS A=n64 B=n7 Y=SUM[30]
XU329 NAND2X2 $PINS A=n375 B=n374 Y=n66
XU330 NAND2X2 $PINS A=n381 B=n50 Y=n41
XU331 INVX1 $PINS A=n93 Y=n91
XU332 XNOR2X1 $PINS A=n83 B=n10 Y=SUM[27]
XU333 NAND2X1 $PINS A=n212 B=n63 Y=n7
XU334 NAND2X1 $PINS A=n209 B=n53 Y=n362
XU335 NOR2X2 $PINS A=B[11] B=A[11] Y=n163
XU336 NAND2X2 $PINS A=B[11] B=A[11] Y=n164
XU337 INVX1 $PINS A=n78 Y=n77
XU338 NAND2X1 $PINS A=B[19] B=A[19] Y=n131
XU339 INVX1 $PINS A=n100 Y=n99
XU340 INVX4 $PINS A=n65 Y=n64
XU341 NOR2X2 $PINS A=B[21] B=A[21] Y=n113
XU342 NAND2X1 $PINS A=B[17] B=A[17] Y=n140
XU343 NAND2X1 $PINS A=n372 B=n221 Y=n106
XU344 NAND2X1 $PINS A=B[13] B=A[13] Y=n156
XU345 NAND2X1 $PINS A=B[10] B=A[10] Y=n168
XU346 INVXL $PINS A=n166 Y=n165
XU347 INVX1 $PINS A=n173 Y=n171
XU348 XOR2X1 $PINS A=n86 B=n11 Y=SUM[26]
XU351 OAI21X2 $PINS A0=n55 A1=n1 B0=n56 Y=n54
XU352 OAI21X2 $PINS A0=n48 A1=n1 B0=n49 Y=n47
XU353 AOI21X1 $PINS A0=n77 A1=n375 B0=n74 Y=n72
XU354 INVX1 $PINS A=n71 Y=n69
XU355 OAI21XL $PINS A0=n86 A1=n84 B0=n85 Y=n83
XU356 NAND2X4 $PINS A=B[30] B=A[30] Y=n63
XU357 OAI21X2 $PINS A0=n160 A1=n164 B0=n161 Y=n159
XU358 INVX1 $PINS A=n202 Y=n201
XU359 OAI21XL $PINS A0=n203 A1=n206 B0=n204 Y=n202
XU360 OAI21XL $PINS A0=n148 A1=n152 B0=n149 Y=n147
XU361 NOR2X1 $PINS A=B[17] B=A[17] Y=n139
XU362 NAND2X1 $PINS A=A[29] B=B[29] Y=n71
XU363 AND2X2 $PINS A=n367 B=n206 Y=SUM[0]
XU364 NAND2X1 $PINS A=A[24] B=B[24] Y=n98
XU365 OR2X4 $PINS A=A[25] B=FE_OCPN6184_N1095 Y=n364
XU366 XNOR2X2 $PINS A=n61 B=n6 Y=SUM[31]
XU367 XNOR2X2 $PINS A=n54 B=n362 Y=SUM[33]
XU368 XNOR2X1 $PINS A=n1 B=n363 Y=SUM[32]
XU369 XNOR2X2 $PINS A=n47 B=n3 Y=SUM[34]
XU370 NAND2X1 $PINS A=n381 B=n46 Y=n3
XU371 OAI21X4 $PINS A0=n64 A1=n62 B0=n63 Y=n61
XU372 INVX1 $PINS A=n87 Y=n86
XU373 NAND2X2 $PINS A=A[35] B=B[35] Y=n39
XU374 NOR2X1 $PINS A=B[13] B=A[13] Y=n155
XU375 INVX1 $PINS A=n51 Y=n49
XU376 NAND2X1 $PINS A=B[12] B=A[12] Y=n161
XU377 NOR2X2 $PINS A=n136 B=n139 Y=n134
XU378 NAND2XL $PINS A=n364 B=n93 Y=n12
XU379 OAI21X2 $PINS A0=n136 A1=n140 B0=n137 Y=n135
XU380 OAI21X4 $PINS A0=n133 A1=n121 B0=n122 Y=n365
XU381 NAND2X1 $PINS A=B[8] B=A[8] Y=n176
XU382 NAND2X1 $PINS A=FE_OFN5964_N1086 B=A[16] Y=n144
XU383 NOR2X2 $PINS A=n59 B=n62 Y=n57
XU384 NAND2X2 $PINS A=n369 B=n371 Y=n121
XU385 AOI21X4 $PINS A0=n96 A1=n364 B0=n91 Y=n89
XU386 NOR2X1 $PINS A=FE_OFN6010_N1084 B=A[14] Y=n151
XU387 NOR2X2 $PINS A=n160 B=n163 Y=n158
XU388 INVX1 $PINS A=n111 Y=n109
XU389 AOI21X4 $PINS A0=n51 A1=n381 B0=n44 Y=n42
XU390 NOR2X2 $PINS A=n106 B=n103 Y=n101
XU391 OAI21X4 $PINS A0=n41 A1=n1 B0=n42 Y=n40
XU392 NAND2X1 $PINS A=B[20] B=A[20] Y=n126
XU393 INVX2 $PINS A=n46 Y=n44
XU394 NOR2X1 $PINS A=FE_OFN5964_N1086 B=A[16] Y=n143
XU395 OAI21X2 $PINS A0=n107 A1=n103 B0=n104 Y=n102
XU396 NAND2X1 $PINS A=FE_OFN6115_N1093 B=A[23] Y=n104
XU397 OR2X2 $PINS A=A[24] B=B[24] Y=n370
XU398 INVX1 $PINS A=n62 Y=n212
XU399 AOI21X4 $PINS A0=n369 A1=n129 B0=n124 Y=n122
XU400 NAND2X1 $PINS A=FE_OCPN6184_N1095 B=A[25] Y=n93
XU401 AOI21X4 $PINS A0=n158 A1=n166 B0=n159 Y=n157
XU402 OAI21X4 $PINS A0=n169 A1=n167 B0=n168 Y=n166
XU403 AOI21X2 $PINS A0=n174 A1=n376 B0=n171 Y=n169
XU404 OAI21X2 $PINS A0=n177 A1=n175 B0=n176 Y=n174
XU405 NAND2X1 $PINS A=FE_OFN6133_N1092 B=A[22] Y=n111
XU406 NOR2X4 $PINS A=FE_OFN6152_N1088 B=A[18] Y=n136
XU407 NOR2X1 $PINS A=n148 B=n151 Y=n146
XU408 AOI21X2 $PINS A0=n146 A1=n154 B0=n147 Y=n145
XU409 NAND2X1 $PINS A=FE_OFN6010_N1084 B=A[14] Y=n152
XU411 OR2X4 $PINS A=FE_OFN6133_N1092 B=A[22] Y=n372
XU412 NAND2X2 $PINS A=FE_OFN6152_N1088 B=A[18] Y=n137
XU413 XNOR2X4 $PINS A=n40 B=n2 Y=SUM[35]
XU414 OAI21X4 $PINS A0=n157 A1=n155 B0=n156 Y=n154
XU415 AOI21X4 $PINS A0=n134 A1=n142 B0=n135 Y=n133
XU416 OAI21X4 $PINS A0=n145 A1=n143 B0=n144 Y=n142
XU417 NAND2X2 $PINS A=B[21] B=A[21] Y=n114
XU418 OR2X4 $PINS A=B[20] B=A[20] Y=n369
XU419 NOR2X2 $PINS A=FE_OFN6115_N1093 B=A[23] Y=n103
XU420 OR2X2 $PINS A=B[7] B=A[7] Y=n373
XU421 OR2X2 $PINS A=B[9] B=A[9] Y=n376
XU422 NOR2X2 $PINS A=A[35] B=B[35] Y=n38
XU423 INVX1 $PINS A=n126 Y=n124
XU424 OR2X2 $PINS A=B[5] B=A[5] Y=n377
XU425 NAND2X1 $PINS A=A[34] B=FE_OCPN6220_N1104 Y=n46
XU426 NAND2BX4 $PINS AN=n38 B=n39 Y=n2
XU427 OR2X2 $PINS A=A[3] B=B[3] Y=n379
XU428 NAND2X2 $PINS A=n364 B=n370 Y=n88
XU429 NAND2BXL $PINS AN=n160 B=n161 Y=n25
XU430 NAND2BXL $PINS AN=n155 B=n156 Y=n24
XU431 NAND2BXL $PINS AN=n163 B=n164 Y=n26
XU432 NAND2BXL $PINS AN=n167 B=n168 Y=n27
XU433 NAND2BXL $PINS AN=n183 B=n184 Y=n31
XU434 NAND2XL $PINS A=n373 B=n181 Y=n30
XU435 NAND2XL $PINS A=B[6] B=A[6] Y=n184
XU436 NAND2XL $PINS A=n376 B=n173 Y=n28
XU437 NAND2BXL $PINS AN=n175 B=n176 Y=n29
XU438 NAND2XL $PINS A=n377 B=n189 Y=n32
XU439 NAND2BXL $PINS AN=n191 B=n192 Y=n33
XU440 NAND2XL $PINS A=n379 B=n197 Y=n34
XU441 NAND2BXL $PINS AN=n199 B=n200 Y=n35
XU442 NAND2XL $PINS A=A[2] B=B[2] Y=n200
XU443 NAND2BXL $PINS AN=n203 B=n204 Y=n36
XU444 OR2XL $PINS A=A[0] B=B[0] Y=n367
XU445 XOR2XL $PINS A=n35 B=n201 Y=SUM[2]
XU446 XOR2XL $PINS A=n36 B=n206 Y=SUM[1]
XU447 NAND2BX1 $PINS AN=n151 B=n152 Y=n23
XU448 NAND2BX1 $PINS AN=n148 B=n149 Y=n22
XU449 OAI21XL $PINS A0=n165 A1=n163 B0=n164 Y=n162
XU450 NAND2X2 $PINS A=A[27] B=B[27] Y=n82
XU451 NOR2X1 $PINS A=B[6] B=A[6] Y=n183
XU452 NOR2X1 $PINS A=B[10] B=A[10] Y=n167
XU453 NAND2X1 $PINS A=B[7] B=A[7] Y=n181
XU454 OR2X4 $PINS A=A[29] B=B[29] Y=n374
XU455 OR2X4 $PINS A=A[28] B=B[28] Y=n375
XU456 NAND2X2 $PINS A=A[33] B=FE_OCPN6217_N1103 Y=n53
XU457 NAND2X2 $PINS A=A[31] B=B[31] Y=n60
XU458 NAND2X1 $PINS A=B[9] B=A[9] Y=n173
XU459 NAND2X1 $PINS A=B[5] B=A[5] Y=n189
XU461 NOR2X1 $PINS A=B[4] B=A[4] Y=n191
XU462 NAND2X1 $PINS A=B[4] B=A[4] Y=n192
XU463 NAND2X1 $PINS A=A[3] B=B[3] Y=n197
XU464 XOR2X1 $PINS A=n141 B=n20 Y=SUM[17]
XU465 XNOR2X1 $PINS A=n132 B=n18 Y=SUM[19]
XU466 NAND2XL $PINS A=n371 B=n131 Y=n18
XU467 XNOR2X1 $PINS A=n138 B=n19 Y=SUM[18]
XU468 XOR2X1 $PINS A=n145 B=n21 Y=SUM[16]
XU469 NAND2XL $PINS A=n226 B=n144 Y=n21
XU471 NOR2X1 $PINS A=A[2] B=B[2] Y=n199
XU472 NAND2X1 $PINS A=A[0] B=B[0] Y=n206
XU473 NOR2X1 $PINS A=A[1] B=B[1] Y=n203
XU474 NAND2X1 $PINS A=A[1] B=B[1] Y=n204
XU475 NAND2XL $PINS A=n71 B=n374 Y=n8
XU476 NAND2XL $PINS A=n375 B=n76 Y=n9
XU477 XOR2X1 $PINS A=n94 B=n12 Y=SUM[25]
XU478 XOR2X1 $PINS A=n153 B=n23 Y=SUM[14]
XU479 XOR2X1 $PINS A=n157 B=n24 Y=SUM[13]
XU480 XNOR2X1 $PINS A=n150 B=n22 Y=SUM[15]
XU481 NAND2XL $PINS A=n370 B=n98 Y=n13
XU482 XNOR2X1 $PINS A=n105 B=n14 Y=SUM[23]
XU483 NAND2XL $PINS A=n372 B=n111 Y=n15
XU484 XOR2X1 $PINS A=n119 B=n16 Y=SUM[21]
XU485 XOR2X1 $PINS A=n127 B=n17 Y=SUM[20]
XU486 NAND2XL $PINS A=n369 B=n126 Y=n17
XU487 XNOR2X1 $PINS A=n162 B=n25 Y=SUM[12]
XU488 XNOR2X1 $PINS A=n174 B=n28 Y=SUM[9]
XU489 XOR2X1 $PINS A=n165 B=n26 Y=SUM[11]
XU490 XOR2XL $PINS A=n29 B=n177 Y=SUM[8]
XU491 XOR2X1 $PINS A=n169 B=n27 Y=SUM[10]
XU492 XNOR2XL $PINS A=n30 B=n182 Y=SUM[7]
XU493 XOR2XL $PINS A=n31 B=n185 Y=SUM[6]
XU494 XNOR2XL $PINS A=n32 B=n190 Y=SUM[5]
XU495 XOR2XL $PINS A=n33 B=n193 Y=SUM[4]
XU496 XNOR2XL $PINS A=n34 B=n198 Y=SUM[3]
XU497 INVX2 $PINS A=n76 Y=n74
XU350 OR2X4 $PINS A=A[34] B=FE_OCPN6220_N1104 Y=n381
.ENDS

.SUBCKT CONV_DW_mult_uns_37_0_0_0 a[35] a[34] a[33] a[32] a[31] a[30] a[29]
+ a[28] a[27] a[26] a[25] a[24] a[23] a[22] a[21] a[20] a[19] a[18] a[17] a[16]
+ a[15] a[14] a[13] a[12] a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2]
+ a[1] a[0] b[13] b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2]
+ b[1] b[0] product[49] product[48] product[47] product[46] product[45]
+ product[44] product[43] product[42] product[41] product[40] product[39]
+ product[38] product[37] product[36] product[35] product[34] product[33]
+ product[32] product[31] product[30] product[29] product[28] product[27]
+ product[26] product[25] product[24] product[23] product[22] product[21]
+ product[20] product[19] product[18] product[17] product[16] product[15]
+ product[14] product[13] product[12] product[11] product[10] product[9]
+ product[8] product[7] product[6] product[5] product[4] product[3] product[2]
+ product[1] product[0] n4908 n4907 n4906 n4905 n6739 n5280 n5286 p1
+ FE_OFN38_N1711 p_2 p_3 p_4 p_5 p_6 FE_OFN83_n FE_OFN99_FE_DBTN21_N1711
*.CONNECT n500 a[17]
*.CONNECT n502 a[15]
*.CONNECT n505 a[12]
*.CONNECT n506 a[11]
*.CONNECT n511 a[6]
*.CONNECT n512 a[5]
*.CONNECT n514 a[3]
*.CONNECT n515 a[2]
*.CONNECT n516 a[1]
XFE_RC_658_0 OAI21X2 $PINS A0=n171 A1=n177 B0=n172 Y=n166
XFE_OFC2240_n179 INVX1 $PINS A=n178 Y=FE_OFN6160_n179
XFE_OFC2239_n179 INVX4 $PINS A=n179 Y=n178
XFE_OFC2227_n4906 INVX1 $PINS A=p_6 Y=FE_OFN6154_n4906
XFE_OFC2208_n177 INVX1 $PINS A=n177 Y=n175
XFE_OFC2118_n5244 INVX1 $PINS A=a[3] Y=n493
XFE_OFC2099_n4908 CLKBUFX3 $PINS A=p_3 Y=FE_OFN6079_n4908
XFE_OFC2096_n4908 INVX1 $PINS A=p_3 Y=FE_RN_2
XFE_OFC2061_n241 INVXL $PINS A=n241 Y=n240
XFE_OFC2058_n221 INVX1 $PINS A=n220 Y=FE_OFN6064_n221
XFE_OFC2057_n221 INVX1 $PINS A=n221 Y=n220
XFE_OFC1859_FE_OFN409_n4971 INVX1 $PINS A=a[7] Y=FE_OFN5916_FE_OFN409_n4971
XFE_OFC1651_n5280 INVX1 $PINS A=p_2 Y=FE_RN_1
XFE_OFC1363_FE_OFN5416_r2240_DIFF_9 INVX1 $PINS A=n487
+ Y=FE_OFN5654_FE_OFN5416_r2240_DIFF_9
XFE_OFC1361_FE_OFN5416_r2240_DIFF_9 BUFX3 $PINS A=a[9] Y=n487
XFE_OFC1349_FE_OFN549_n4975 INVX1 $PINS A=a[15] Y=n481
XFE_OFC1090_n138 INVX1 $PINS A=n138 Y=n136
XFE_OFC1075_n4983 INVX1 $PINS A=a[12] Y=n484
XFE_OFC961_r2240_DIFF_17 INVX1 $PINS A=a[17] Y=FE_OFN633_r2240_DIFF_17
XFE_OFC915_r2240_DIFF_11 INVX1 $PINS A=a[11] Y=n485
XFE_OFC653_r2240_DIFF_4 INVX1 $PINS A=a[4] Y=n492
XFE_DBTC156_n150 INVX8 $PINS A=n150 Y=FE_DBTN156_n150
XU47 XNOR2X2 $PINS A=n74 B=n6 Y=product[29]
XU82 OAI21X2 $PINS A0=FE_DBTN156_n150 A1=n91 B0=n92 Y=n90
XU93 XNOR2X4 $PINS A=n110 B=n10 Y=product[25]
XU101 NOR2X2 $PINS A=n115 B=n108 Y=n102
XU125 NOR2X1 $PINS A=n126 B=n133 Y=n124
XU131 XNOR2X4 $PINS A=n135 B=n13 Y=product[22]
XU141 XNOR2X4 $PINS A=n146 B=n14 Y=product[21]
XU153 NOR2X2 $PINS A=n347 B=n355 Y=n144
XU166 NOR2X2 $PINS A=n155 B=n160 Y=n153
XU170 NOR2X2 $PINS A=n367 B=n376 Y=n155
XU180 NOR2X2 $PINS A=n377 B=n386 Y=n160
XU182 XOR2X4 $PINS A=n173 B=n18 Y=product[17]
XU188 NOR2X1 $PINS A=n171 B=n176 Y=n165
XU192 NOR2X2 $PINS A=n387 B=n396 Y=n171
XU200 NOR2X2 $PINS A=n397 B=n406 Y=n176
XU204 AOI21X4 $PINS A0=n199 A1=n180 B0=n181 Y=n179
XU206 OAI21X1 $PINS A0=n611 A1=n182 B0=n183 Y=n181
XU229 NOR2X1 $PINS A=n427 B=n436 Y=n192
XU233 OAI21X4 $PINS A0=n200 A1=n212 B0=n201 Y=n199
XU344 ADDFX2 $PINS A=n334 B=n339 CI=n332 S=n330 CO=n329
XU364 ADDFHX2 $PINS A=n371 B=n378 CI=n369 S=n367 CO=n366
XU377 ADDFX2 $PINS A=a[7] B=n404 CI=n395 S=n393 CO=n392
XU389 ADDFHX1 $PINS A=FE_OFN6154_n4906 B=n428 CI=n419 S=n417 CO=n416
XU394 ADDFHX1 $PINS A=n483 B=n438 CI=n429 S=n427 CO=n426
XU464 ADDFX2 $PINS A=n311 B=n316 CI=n309 S=n307 CO=n306
XU465 INVX1 $PINS A=n118 Y=n120
XU466 NAND2BX1 $PINS AN=n171 B=n172 Y=n18
XU467 OAI21XL $PINS A0=n1 A1=n55 B0=n56 Y=n54
XU468 OAI21X1 $PINS A0=n1 A1=n66 B0=n67 Y=n65
XU469 ADDFX2 $PINS A=FE_OFN83_n B=n484 CI=n4905 S=n311 CO=n310
XU470 ADDFHX2 $PINS A=n4907 B=n441 CI=n484 S=n439 CO=n438
XU472 NOR2X2 $PINS A=n185 B=n182 Y=n180
XU473 AOI21X1 $PINS A0=n121 A1=n102 B0=n103 Y=n101
XU474 CLKINVX3 $PINS A=n608 Y=n121
XU475 NOR2X2 $PINS A=n592 B=FE_DBTN156_n150 Y=n594
XU476 NOR2X4 $PINS A=n594 B=n83 Y=n1
XU477 INVX1 $PINS A=n82 Y=n592
XU479 NOR2X1 $PINS A=n118 B=n84 Y=n82
XU480 OAI21X2 $PINS A0=n1 A1=n75 B0=n76 Y=n74
XU482 INVX1 $PINS A=n1 Y=n596
XU483 ADDFX2 $PINS A=n381 B=n388 CI=n379 S=n377 CO=n376
XU484 NAND2X1 $PINS A=n622 B=n621 Y=n200
XU485 AOI22X1 $PINS A0=n58 A1=n626 B0=n287 B1=n286 Y=n49
XU486 OAI21XL $PINS A0=n59 A1=n76 B0=n60 Y=n58
XU487 NOR2X1 $PINS A=n321 B=n315 Y=n108
XU488 ADDFHX1 $PINS A=n319 B=n323 CI=n317 S=n315 CO=n314
XU489 NOR2X1 $PINS A=n492 B=n451 Y=n238
XU490 NAND2X1 $PINS A=n492 B=n451 Y=n239
XU493 NOR2X1 $PINS A=n322 B=n329 Y=n115
XU494 ADDFHX1 $PINS A=n333 B=n324 CI=n331 S=n322 CO=n321
XU495 OAI21XL $PINS A0=n163 A1=n155 B0=n156 Y=n154
XU496 AOI21X2 $PINS A0=n153 A1=n166 B0=n154 Y=n152
XU497 NAND2X1 $PINS A=n261 B=n116 Y=n11
XU498 OAI21X1 $PINS A0=n108 A1=n116 B0=n109 Y=n103
XU499 NAND2X1 $PINS A=n322 B=n329 Y=n116
XU500 XNOR2X2 $PINS A=n117 B=n11 Y=product[24]
XU501 NOR2X2 $PINS A=n407 B=n416 Y=n182
XU502 ADDFX2 $PINS A=n411 B=n418 CI=n409 S=n407 CO=n406
XU503 NAND2X1 $PINS A=n387 B=n396 Y=n172
XU504 ADDFX2 $PINS A=n391 B=n398 CI=n389 S=n387 CO=n386
XU505 OAI21XL $PINS A0=n168 A1=n160 B0=n163 Y=n159
XU506 INVX1 $PINS A=n166 Y=n168
XU507 ADDFX2 $PINS A=n512 B=n443 CI=n448 S=n441 CO=n440
XU508 ADDFX2 $PINS A=n451 B=a[4] CI=n456 S=n449 CO=n448
XU509 ADDFX2 $PINS A=n424 B=n415 CI=n506 S=n413 CO=n412
XU510 ADDFX2 $PINS A=n414 B=n405 CI=n505 S=n403 CO=n402
XU511 ADDFX2 $PINS A=n487 B=a[13] CI=n412 S=n401 CO=n400
XU512 ADDFX2 $PINS A=p_5 B=n403 CI=n410 S=n399 CO=n398
XU514 ADDFX2 $PINS A=n511 B=n4907 CI=n505 S=n375 CO=n374
XU518 ADDFX2 $PINS A=n328 B=n335 CI=n326 S=n324 CO=n323
XU520 ADDFX2 $PINS A=n420 B=n481 CI=n413 S=n409 CO=n408
XU521 ADDFX2 $PINS A=n402 B=n393 CI=n400 S=n389 CO=n388
XU522 ADDFX2 $PINS A=n4906 B=n383 CI=n390 S=n379 CO=n378
XU523 NAND2X1 $PINS A=n397 B=n406 Y=n177
XU524 OR2X2 $PINS A=n417 B=n426 Y=n620
XU525 AOI21X1 $PINS A0=n121 A1=n93 B0=n94 Y=n92
XU527 NAND2X1 $PINS A=n620 B=n272 Y=n185
XU528 ADDFHX2 $PINS A=n370 B=n368 CI=n358 S=n356 CO=n355
XU529 INVX1 $PINS A=n133 Y=n263
XU530 ADDFHX2 $PINS A=n487 B=n446 CI=n439 S=n437 CO=n436
XU533 CLKINVX3 $PINS A=a[21] Y=n476
XU535 OAI2BB2X4 $PINS A0N=n347 A1N=n355 B0=n144 B1=n148 Y=n139
XU536 NOR2BX1 $PINS AN=n89 B=n88 Y=n619
XU537 NAND2BX1 $PINS AN=n108 B=n109 Y=n10
XU538 NAND2X2 $PINS A=n138 B=n124 Y=n118
XU539 AND2X2 $PINS A=n437 B=n444 Y=n203
XU540 OAI21XL $PINS A0=n88 A1=n98 B0=n89 Y=n87
XU541 OAI21XL $PINS A0=n1 A1=n48 B0=n49 Y=n47
XU542 NOR2BX1 $PINS AN=n102 B=n95 Y=n93
XU543 NAND2BX1 $PINS AN=n45 B=n46 Y=n3
XU544 OAI2BB1X1 $PINS A0N=n103 A1N=n595 B0=n98 Y=n94
XU545 INVX1 $PINS A=n95 Y=n595
XU546 XOR3X2 $PINS A=n54 B=n287 C=n286 Y=product[31]
XU547 OAI2BB2X1 $PINS A0N=n458 A1N=n453 B0=n215 B1=n219 Y=n214
XU548 AOI21X1 $PINS A0=n43 A1=n596 B0=n44 Y=n597
XU549 INVX1 $PINS A=n597 Y=n40
XU550 NOR2X1 $PINS A=n463 B=p_4 Y=n222
XU551 NOR2X1 $PINS A=n238 B=n235 Y=n233
XU552 NAND2BX1 $PINS AN=n605 B=n620 Y=n21
XU553 NAND2BX1 $PINS AN=n147 B=n148 Y=n15
XU554 NAND2X1 $PINS A=n407 B=n416 Y=n183
XU555 NOR2X1 $PINS A=n301 B=n306 Y=n88
XU556 OAI2BB2X1 $PINS A0N=n5286 A1N=n443 B0=n235 B1=n239 Y=n234
XU557 NAND2BX1 $PINS AN=n126 B=n127 Y=n616
XU558 NAND2X1 $PINS A=n120 B=n93 Y=n91
XU559 NAND2BX1 $PINS AN=n176 B=n177 Y=n19
XU560 OAI2BB2X1 $PINS A0N=n471 A1N=n6739 B0=n232 B1=n230 Y=n229
XU561 XNOR2X1 $PINS A=n347 B=n355 Y=n14
XU562 AND2X2 $PINS A=n417 B=n426 Y=n605
XU563 AOI22X1 $PINS A0=n229 A1=n625 B0=n467 B1=FE_OFN5916_FE_OFN409_n4971
+ Y=n224
XU564 OAI21X2 $PINS A0=FE_DBTN156_n150 A1=n100 B0=n101 Y=n99
XU565 NAND2X1 $PINS A=n427 B=n436 Y=n193
XU566 OAI2BB2X1 $PINS A0N=n463 A1N=p_4 B0=n224 B1=n222 Y=n221
XU567 OAI21X2 $PINS A0=FE_DBTN156_n150 A1=n136 B0=n137 Y=n135
XU569 NOR2X1 $PINS A=n459 B=FE_OFN5654_FE_OFN5416_r2240_DIFF_9 Y=n218
XU570 NAND2X1 $PINS A=n120 B=n102 Y=n100
XU571 XOR3X2 $PINS A=n184 B=n407 C=n416 Y=product[15]
XU572 XNOR3X2 $PINS A=n232 B=n471 C=n6739 Y=product[6]
XU573 OAI2BB1X1 $PINS A0N=n44 A1N=n628 B0=n39 Y=n599
XU574 NAND2XL $PINS A=a[18] B=n363 Y=n602
XU575 AOI21X1 $PINS A0=n121 A1=n261 B0=n114 Y=n112
XU576 XOR2X2 $PINS A=n90 B=n619 Y=product[27]
XU577 NAND2BX1 $PINS AN=n242 B=n243 Y=n32
XU578 XOR3X2 $PINS A=n492 B=n451 C=n241 Y=product[4]
XU579 XOR3X2 $PINS A=FE_OFN6064_n221 B=n459
+ C=FE_OFN5654_FE_OFN5416_r2240_DIFF_9 Y=product[9]
XU580 AOI31X1 $PINS A0=n596 A1=n43 A2=n628 B0=n599 Y=product[34]
XU581 XOR3X2 $PINS A=n237 B=n5286 C=n443 Y=product[5]
XU582 XNOR3X2 $PINS A=n206 B=n437 C=n444 Y=product[12]
XU583 XOR3X2 $PINS A=n229 B=n467 C=FE_OFN5916_FE_OFN409_n4971 Y=product[7]
XU584 AOI22X1 $PINS A0=n288 A1=n289 B0=n71 B1=n624 Y=n60
XU585 NOR2X1 $PINS A=n5286 B=n443 Y=n235
XU586 NAND2BX1 $PINS AN=n160 B=n163 Y=n17
XU587 XNOR3X2 $PINS A=n224 B=n463 C=p_4 Y=product[8]
XU588 XOR3X2 $PINS A=n217 B=n458 C=n453 Y=product[10]
XU589 NOR2BX1 $PINS AN=n98 B=n95 Y=n618
XU590 NAND2X1 $PINS A=n263 B=n134 Y=n13
XU591 INVX1 $PINS A=n134 Y=n132
XU592 ADDFX2 $PINS A=n487 B=FE_OFN83_n CI=n4905 S=n373 CO=n372
XU593 OAI21X2 $PINS A0=FE_DBTN156_n150 A1=n129 B0=n130 Y=n128
XU594 ADDFXL $PINS A=FE_RN_1 B=n505 CI=n487 S=n344 CO=n343
XU595 AOI21X1 $PINS A0=n233 A1=n241 B0=n234 Y=n232
XU596 ADDFX2 $PINS A=n500 B=n487 CI=a[13] S=n362 CO=n361
XU597 INVXL $PINS A=n212 Y=n211
XU598 ADDFX2 $PINS A=a[3] B=n512 CI=n511 S=n405 CO=n404
XU600 ADDFX2 $PINS A=a[13] B=FE_OFN633_r2240_DIFF_17 CI=n4906 S=n391 CO=n390
XU601 ADDFX2 $PINS A=n401 B=n408 CI=n399 S=n397 CO=n396
XU602 ADDFHX2 $PINS A=n440 B=n431 CI=n487 S=n429 CO=n428
XU603 ADDFX2 $PINS A=a[2] B=n512 CI=n511 S=n461 CO=n460
XU605 ADDFX2 $PINS A=n353 B=n361 CI=n351 S=n349 CO=n348
XU606 XOR2X1 $PINS A=n363 B=n601 Y=n351
XU607 ADDFHX1 $PINS A=FE_RN_2 B=n373 CI=n380 S=n369 CO=n368
XU608 ADDFX2 $PINS A=n384 B=n375 CI=n382 S=n371 CO=n370
XU609 ADDFHX1 $PINS A=n342 B=n348 CI=n340 S=n338 CO=n337
XU611 INVX1 $PINS A=a[13] Y=n483
XU612 NAND2X1 $PINS A=n321 B=n315 Y=n109
XU613 AOI21X1 $PINS A0=n139 A1=n263 B0=n132 Y=n130
XU614 NAND2X1 $PINS A=n138 B=n263 Y=n129
XU615 ADDFHX2 $PINS A=n359 B=n357 CI=n349 S=n347 CO=n346
XU616 NAND2X2 $PINS A=n356 B=n366 Y=n148
XU617 NOR2X2 $PINS A=n356 B=n366 Y=n147
XU618 INVX1 $PINS A=n139 Y=n137
XU619 NOR2X2 $PINS A=n307 B=n314 Y=n95
XU620 NAND2X1 $PINS A=n307 B=n314 Y=n98
XU621 NOR2X1 $PINS A=n88 B=n95 Y=n86
XU623 NAND2X1 $PINS A=n609 B=n156 Y=n617
XU624 OAI21XL $PINS A0=n220 A1=n218 B0=n219 Y=n217
XU627 CMPR32X1 $PINS A=a[17] B=a[13] C=n4906 S=n326 CO=n325
XU628 OAI21X1 $PINS A0=n608 A1=n84 B0=n85 Y=n83
XU629 AOI21X1 $PINS A0=n178 A1=n165 B0=n166 Y=n164
XU630 INVX1 $PINS A=n199 Y=n198
XU631 ADDFHX1 $PINS A=n4905 B=n364 CI=n374 S=n360 CO=n359
XU632 ADDFX2 $PINS A=n449 B=a[7] CI=n454 S=n447 CO=n446
XU633 OR2XL $PINS A=n367 B=n376 Y=n609
XU634 OAI21X4 $PINS A0=n600 A1=FE_OFN6160_n179 B0=n152 Y=n150
XU635 NAND2X1 $PINS A=n153 B=n165 Y=n600
XU637 XNOR2X2 $PINS A=n65 B=n5 Y=product[30]
XU638 ADDFX2 $PINS A=a[4] B=p_2 CI=n425 S=n423 CO=n422
XU639 ADDFX2 $PINS A=a[4] B=n511 CI=p_2 S=n395 CO=n394
XU640 AOI21X2 $PINS A0=n213 A1=FE_OFN6064_n221 B0=n214 Y=n212
XU641 NOR2X1 $PINS A=n218 B=n215 Y=n213
XU642 XOR2X1 $PINS A=a[18] B=n4906 Y=n601
XU643 NAND2X1 $PINS A=n4906 B=n363 Y=n603
XU644 NAND2XL $PINS A=n4906 B=a[18] Y=n604
XU645 NAND3X1 $PINS A=n604 B=n602 C=n603 Y=n350
XU646 ADDFX2 $PINS A=FE_RN_1 B=a[7] CI=a[20] S=n364 CO=n363
XU647 AOI21X1 $PINS A0=n158 A1=n178 B0=n159 Y=n157
XU648 ADDFHX4 $PINS A=a[1] B=n450 CI=a[2] S=n443 CO=n442
XU649 NOR2X1 $PINS A=n346 B=n338 Y=n133
XU650 OAI21XL $PINS A0=n242 A1=n627 B0=n243 Y=n241
XU651 ADDFX2 $PINS A=n464 B=n461 CI=n462 S=n459 CO=n458
XU652 NOR2X1 $PINS A=n458 B=n453 Y=n215
XU653 XOR2X2 $PINS A=n1 B=n7 Y=product[28]
XU654 AOI21X1 $PINS A0=n103 A1=n86 B0=n87 Y=n85
XU655 NAND2X1 $PINS A=n330 B=n337 Y=n127
XU656 OAI21XL $PINS A0=n126 A1=n134 B0=n127 Y=n125
XU657 NOR2X2 $PINS A=n330 B=n337 Y=n126
XU658 ADDFX2 $PINS A=a[2] B=n512 CI=a[4] S=n415 CO=n414
XU659 ADDFX2 $PINS A=n511 B=p_2 CI=n433 S=n431 CO=n430
XU661 ADDFX2 $PINS A=n394 B=n4907 CI=n502 S=n383 CO=n382
XU662 ADDFX2 $PINS A=n362 B=n372 CI=n360 S=n358 CO=n357
XU663 ADDFX2 $PINS A=n423 B=n430 CI=n421 S=n419 CO=n418
XU664 ADDFX2 $PINS A=a[1] B=n512 CI=a[4] S=n465 CO=n464
XU665 ADDFX2 $PINS A=n505 B=n476 CI=a[17] S=n305 CO=n304
XU666 ADDFX2 $PINS A=n352 B=n344 CI=n350 S=n340 CO=n339
XU667 ADDFX2 $PINS A=FE_OFN83_n B=n484 CI=a[18] S=n319 CO=n318
XU668 ADDFX2 $PINS A=a[2] B=a[3] CI=n442 S=n471 CO=n470
XU669 ADDFX2 $PINS A=n385 B=n392 CI=n478 S=n381 CO=n380
XU670 ADDFX2 $PINS A=a[4] B=n457 CI=n470 S=n467 CO=n466
XU671 ADDFX2 $PINS A=n456 B=n465 CI=n466 S=n463 CO=n462
XU673 ADDFX2 $PINS A=a[7] B=n460 CI=n455 S=n453 CO=n452
XU674 ADDFX2 $PINS A=n310 B=n308 CI=n303 S=n301 CO=n300
XU676 NOR2BX1 $PINS AN=n165 B=n160 Y=n158
XU678 NAND2X1 $PINS A=n346 B=n338 Y=n134
XU679 NAND2X1 $PINS A=n445 B=n447 Y=n210
XU680 INVX1 $PINS A=n210 Y=n208
XU681 INVX1 $PINS A=n192 Y=n272
XU682 NAND2X1 $PINS A=n459 B=FE_OFN5654_FE_OFN5416_r2240_DIFF_9 Y=n219
XU683 XNOR2X1 $PINS A=n47 B=n3 Y=product[32]
XU684 XNOR2X1 $PINS A=n191 B=n21 Y=product[14]
XU685 NAND2X1 $PINS A=n77 B=n76 Y=n7
XU686 OAI21XL $PINS A0=n49 A1=n45 B0=n46 Y=n44
XU687 ADDFX2 $PINS A=n4906 B=n327 CI=n325 S=n317 CO=n316
XU688 ADDFX2 $PINS A=n485 B=n4907 CI=n452 S=n445 CO=n444
XU689 ADDFX1 $PINS A=n4907 B=n485 CI=n500 S=n353 CO=n352
XU691 NAND2X1 $PINS A=n102 B=n86 Y=n84
XU692 ADDHXL $PINS A=a[0] B=n514 S=n457 CO=n456
XU693 AOI21X2 $PINS A0=n622 A1=n208 B0=n203 Y=n201
XU694 OR2X2 $PINS A=n445 B=n447 Y=n621
XU695 ADDFX2 $PINS A=n422 B=n4907 CI=n505 S=n411 CO=n410
XU696 AOI2BB1X2 $PINS A0N=n610 A1N=n193 B0=n605 Y=n611
XU697 AOI21X4 $PINS A0=n124 A1=n139 B0=n125 Y=n608
XU698 ADDFX2 $PINS A=n457 B=n511 CI=FE_RN_1 S=n455 CO=n454
XU699 NOR2X1 $PINS A=n417 B=n426 Y=n610
XU700 NAND2X1 $PINS A=n367 B=n376 Y=n156
XU701 AOI2BB1X4 $PINS A0N=n179 A1N=n176 B0=n175 Y=n173
XU703 XOR2X1 $PINS A=n164 B=n17 Y=product[18]
XU704 OAI21XL $PINS A0=FE_DBTN156_n150 A1=n118 B0=n608 Y=n117
XU705 OAI21X2 $PINS A0=FE_DBTN156_n150 A1=n111 B0=n112 Y=n110
XU706 ADDFX2 $PINS A=a[1] B=n434 CI=a[3] S=n425 CO=n424
XU707 OR2XL $PINS A=a[2] B=n247 Y=n627
XU708 XOR2X1 $PINS A=a[2] B=n247 Y=product[2]
XU709 NAND2XL $PINS A=n120 B=n261 Y=n111
XU710 XNOR2X4 $PINS A=n178 B=n19 Y=product[16]
XU711 ADDFX2 $PINS A=n435 B=a[3] CI=n442 S=n433 CO=n432
XU712 ADDHXL $PINS A=a[0] B=n516 S=n451 CO=n450
XU713 ADDFX2 $PINS A=n432 B=a[7] CI=n506 S=n421 CO=n420
XU714 ADDFX2 $PINS A=n336 B=p_3 CI=n341 S=n332 CO=n331
XU715 ADDFX2 $PINS A=a[13] B=p_3 CI=n318 S=n309 CO=n308
XU716 CMPR32X1 $PINS A=FE_OFN83_n B=a[18] C=p_3 S=n342 CO=n341
XU717 OAI21X4 $PINS A0=FE_DBTN156_n150 A1=n147 B0=n148 Y=n146
XU718 NAND2X1 $PINS A=n57 B=n626 Y=n48
XU720 XOR2X2 $PINS A=FE_DBTN156_n150 B=n15 Y=product[20]
XU721 NOR2XL $PINS A=n59 B=n75 Y=n57
XU722 NAND2XL $PINS A=n301 B=n306 Y=n89
XU723 XOR2X1 $PINS A=n157 B=n617 Y=product[19]
XU724 NOR2X1 $PINS A=n300 B=n295 Y=n75
XU725 INVX1 $PINS A=n76 Y=n78
XU726 NAND2XL $PINS A=n77 B=n623 Y=n66
XU727 XNOR2X1 $PINS A=a[1] B=FE_OFN99_FE_DBTN21_N1711 Y=product[1]
XU728 XNOR2X4 $PINS A=n128 B=n616 Y=product[23]
XU729 NOR2X2 $PINS A=n144 B=n147 Y=n138
XU730 INVXL $PINS A=n116 Y=n114
XU731 NAND2XL $PINS A=n623 B=n73 Y=n6
XU732 XOR2X1 $PINS A=n198 B=n22 Y=product[13]
XU733 INVXL $PINS A=n58 Y=n56
XU734 NAND2XL $PINS A=n624 B=n64 Y=n5
XU735 NAND2XL $PINS A=n288 B=n289 Y=n64
XU736 INVX1 $PINS A=n57 Y=n55
XU737 INVXL $PINS A=n115 Y=n261
XU738 INVX1 $PINS A=n75 Y=n77
XU739 NAND2X1 $PINS A=n377 B=n386 Y=n163
XU740 NAND2X1 $PINS A=n300 B=n295 Y=n76
XU741 NOR2X1 $PINS A=n48 B=n45 Y=n43
XU742 NAND2X1 $PINS A=n623 B=n624 Y=n59
XU744 AOI21X1 $PINS A0=n78 A1=n623 B0=n71 Y=n67
XU745 OAI21XL $PINS A0=n198 A1=n185 B0=n611 Y=n184
XU746 OAI21XL $PINS A0=n198 A1=n192 B0=n193 Y=n191
XU747 OAI21XL $PINS A0=n240 A1=n238 B0=n239 Y=n237
XU748 XNOR2X1 $PINS A=n211 B=n24 Y=product[11]
XU749 NAND2XL $PINS A=n621 B=n210 Y=n24
XU750 NAND2XL $PINS A=n272 B=n193 Y=n22
XU751 AOI21X1 $PINS A0=n211 A1=n621 B0=n208 Y=n206
XU752 INVX1 $PINS A=n73 Y=n71
XU753 OR2X2 $PINS A=n437 B=n444 Y=n622
XU754 OR2X2 $PINS A=n294 B=n290 Y=n623
XU755 NAND2BX1 $PINS AN=a[1] B=FE_OFN38_N1711 Y=n247
XU756 NOR2X1 $PINS A=n471 B=n6739 Y=n230
XU757 OR2X2 $PINS A=n288 B=n289 Y=n624
XU758 NAND2X1 $PINS A=n294 B=n290 Y=n73
XU759 XOR2X1 $PINS A=n32 B=n627 Y=product[3]
XU760 ADDFX2 $PINS A=n304 B=n297 CI=n302 S=n295 CO=n294
XU761 OR2X2 $PINS A=n467 B=FE_OFN5916_FE_OFN409_n4971 Y=n625
XU762 XNOR2X1 $PINS A=n40 B=n2 Y=product[33]
XU763 NAND2X1 $PINS A=n628 B=n39 Y=n2
XU764 NOR2XL $PINS A=FE_RN_2 B=n285 Y=n45
XU765 OR2X2 $PINS A=n287 B=n286 Y=n626
XU766 NAND2XL $PINS A=FE_RN_2 B=n285 Y=n46
XU767 INVXL $PINS A=a[18] Y=n478
XU769 ADDFX2 $PINS A=FE_OFN633_r2240_DIFF_17 B=a[18] CI=n4905 S=n292 CO=n291
XU770 ADDFX2 $PINS A=n4905 B=n4906 CI=n305 S=n303 CO=n302
XU771 ADDFX2 $PINS A=n512 B=a[7] CI=n506 S=n385 CO=n384
XU773 ADDFX2 $PINS A=n476 B=FE_OFN6079_n4908 CI=n291 S=n288 CO=n287
XU774 ADDFX2 $PINS A=FE_OFN6079_n4908 B=n296 CI=n292 S=n290 CO=n289
XU775 CMPR32X1 $PINS A=FE_OFN83_n B=FE_OFN633_r2240_DIFF_17 C=a[18] S=n297
+ CO=n296
XU776 CMPR32X1 $PINS A=n476 B=a[17] C=a[18] S=n286 CO=n285
XU777 OR2XL $PINS A=FE_OFN6079_n4908 B=n476 Y=n628
XU778 NAND2XL $PINS A=FE_OFN6079_n4908 B=n476 Y=n39
XU779 ADDFX2 $PINS A=a[13] B=n4905 CI=n343 S=n334 CO=n333
XU780 ADDHXL $PINS A=a[0] B=n515 S=n435 CO=n434
XU781 ADDFX2 $PINS A=p_2 B=n506 CI=n476 S=n328 CO=n327
XU782 ADDFX2 $PINS A=n506 B=n505 CI=n476 S=n336 CO=n335
XU783 NOR2XL $PINS A=n493 B=a[0] Y=n242
XU784 NAND2XL $PINS A=n493 B=a[0] Y=n243
XU481 XNOR2X4 $PINS A=n99 B=n644 Y=product[26]
XU534 INVX1 $PINS A=n618 Y=n644
.ENDS

.SUBCKT CONV_DW_mult_uns_35_0_0_0 a[35] a[34] a[33] a[32] a[31] a[30] a[29]
+ a[28] a[27] a[26] a[25] a[24] a[23] a[22] a[21] a[20] a[19] a[18] a[17] a[16]
+ a[15] a[14] a[13] a[12] a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2]
+ a[1] a[0] b[15] b[14] b[13] b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4]
+ b[3] b[2] b[1] b[0] product[51] product[50] product[49] product[48]
+ product[47] product[46] product[45] product[44] product[43] product[42]
+ product[41] product[40] product[39] product[38] product[37] product[36]
+ product[35] product[34] product[33] product[32] product[31] product[30]
+ product[29] product[28] product[27] product[26] product[25] product[24]
+ product[23] product[22] product[21] product[20] product[19] product[18]
+ product[17] product[16] product[15] product[14] product[13] product[12]
+ product[11] product[10] product[9] product[8] product[7] product[6]
+ product[5] product[4] product[3] product[2] product[1] product[0] p1
+ FE_OFN5835_N1281
*.CONNECT n463 a[19]
*.CONNECT n464 a[18]
*.CONNECT n476 a[4]
XFE_OCPC2328_r2236_DIFF_5 BUFX3 $PINS A=a[5] Y=FE_OCPN6232_r2236_DIFF_5
XFE_OCPC2322_n1 BUFX4 $PINS A=n1 Y=FE_OCPN6226_n1
XFE_OCPC2317_n148 BUFX3 $PINS A=n148 Y=FE_OCPN6221_n148
XFE_OFC2206_n2468 CLKINVX3 $PINS A=n451 Y=FE_OFN6140_n2468
XFE_OFC2205_n2468 CLKBUFX8 $PINS A=a[10] Y=n451
XFE_OFC2189_r2236_DIFF_8 BUFX4 $PINS A=a[8] Y=FE_OFN6137_r2236_DIFF_8
XFE_OFC2154_n5254 CLKINVX3 $PINS A=n446 Y=FE_OFN5940_n5254
XFE_OFC2153_n5254 INVX8 $PINS A=a[15] Y=n446
XFE_OFC2152_r2236_DIFF_12 CLKINVX3 $PINS A=n449 Y=FE_OFN6104_r2236_DIFF_12
XFE_OFC2151_r2236_DIFF_12 CLKINVX3 $PINS A=a[12] Y=n449
XFE_OFC2111_r2236_DIFF_14 INVX2 $PINS A=n447 Y=FE_OFN5908_r2236_DIFF_14
XFE_OFC2110_r2236_DIFF_14 CLKBUFX8 $PINS A=a[14] Y=n447
XFE_OFC1855_r2236_DIFF_2 INVX1 $PINS A=FE_OFN378_r2236_DIFF_2
+ Y=FE_OFN5915_r2236_DIFF_2
XFE_OFC1854_r2236_DIFF_2 BUFX3 $PINS A=a[2] Y=FE_OFN378_r2236_DIFF_2
XFE_OFC1813_r2236_DIFF_1 INVX1 $PINS A=a[1] Y=FE_OFN5894_r2236_DIFF_1
XFE_OFC1665_n194 CLKINVX3 $PINS A=n194 Y=n193
XFE_OFC1636_r2236_DIFF_9 INVX8 $PINS A=n452 Y=FE_OFN5801_r2236_DIFF_9
XFE_OFC1635_r2236_DIFF_9 INVX4 $PINS A=a[9] Y=n452
XFE_OFC1580_r2236_DIFF_17 CLKINVX3 $PINS A=n444 Y=FE_OFN5772_r2236_DIFF_17
XFE_OFC1579_r2236_DIFF_17 CLKINVX3 $PINS A=a[17] Y=n444
XFE_OFC1498_r2236_DIFF_7 CLKINVX3 $PINS A=n454 Y=FE_OFN5726_r2236_DIFF_7
XFE_OFC1497_r2236_DIFF_7 INVX4 $PINS A=a[7] Y=n454
XFE_OFC1435_r2236_DIFF_6 CLKINVX3 $PINS A=a[6] Y=n572
XFE_OFC1375_r2236_DIFF_11 CLKINVX3 $PINS A=a[11] Y=FE_OFN269_r2236_DIFF_11
XFE_OFC1354_r2236_DIFF_5 CLKINVX3 $PINS A=n456 Y=FE_OFN5650_r2236_DIFF_5
XFE_OFC1353_r2236_DIFF_5 CLKINVX3 $PINS A=FE_OCPN6232_r2236_DIFF_5 Y=n456
XFE_OFC1104_r2236_DIFF_16 CLKINVX3 $PINS A=a[16] Y=n445
XFE_OFC1086_r2236_DIFF_18 INVX2 $PINS A=a[18] Y=n443
XFE_OFC1076_n138 INVX1 $PINS A=n138 Y=FE_DBTN155_n138
XFE_OFC1041_n163 INVX4 $PINS A=n163 Y=n162
XFE_OFC1031_r2236_DIFF_13 INVX2 $PINS A=a[13] Y=n448
XFE_OFC1030_n559 INVX1 $PINS A=n559 Y=FE_DBTN153_n559
XFE_OFC834_r2236_DIFF_3 INVX1 $PINS A=a[3] Y=FE_OFN168_r2236_DIFF_3
XFE_OFC224_n433 INVX1 $PINS A=n433 Y=n619
XFE_DBTC154_n161 CLKINVX3 $PINS A=n161 Y=FE_DBTN154_n161
XU88 AOI21X1 $PINS A0=n1 A1=n99 B0=n100 Y=n98
XU94 OAI21X1 $PINS A0=n105 A1=n111 B0=n106 Y=n100
XU97 NOR2X1 $PINS A=n302 B=n297 Y=n105
XU107 XOR2X4 $PINS A=n119 B=n11 Y=product[26]
XU110 AOI21X4 $PINS A0=n128 A1=n115 B0=n116 Y=n114
XU111 NOR2X4 $PINS A=n122 B=n117 Y=n115
XU115 NOR2X2 $PINS A=n313 B=n308 Y=n117
XU125 NOR2X2 $PINS A=n314 B=n319 Y=n122
XU133 NOR2X2 $PINS A=n133 B=n138 Y=n127
XU137 NOR2X4 $PINS A=n320 B=n327 Y=n133
XU140 AOI21X2 $PINS A0=n140 A1=FE_DBTN155_n138 B0=n137 Y=n135
XU149 AOI21X4 $PINS A0=n150 A1=n142 B0=n143 Y=n141
XU160 NOR2X2 $PINS A=n344 B=n351 Y=n147
XU161 NAND2X1 $PINS A=n344 B=n351 Y=n148
XU164 OAI21X4 $PINS A0=n163 A1=n151 B0=n152 Y=n150
XU166 AOI21X2 $PINS A0=n583 A1=FE_DBTN154_n161 B0=n154 Y=n152
XU180 NAND2X2 $PINS A=n360 B=n367 Y=n161
XU183 AOI21X4 $PINS A0=n164 A1=n172 B0=n165 Y=n163
XU335 ADDFHX4 $PINS A=n324 B=n329 CI=n322 S=n320 CO=n319
XU355 ADDFHX2 $PINS A=n444 B=n369 CI=n362 S=n360 CO=n359
XU428 NAND2X1 $PINS A=n426 B=n429 Y=n218
XU429 ADDFHX1 $PINS A=n431 B=n428 CI=n454 S=n426 CO=n425
XU430 NAND2X1 $PINS A=n323 B=n316 Y=n550
XU431 OR2X2 $PINS A=n426 B=n429 Y=n585
XU432 XOR2X4 $PINS A=n126 B=n577 Y=product[25]
XU433 ADDFX2 $PINS A=FE_OFN5772_r2236_DIFF_17 B=n317 CI=n312 S=n310 CO=n309
XU434 INVX1 $PINS A=n237 Y=n235
XU435 OAI2BB1X1 $PINS A0N=n244 A1N=n598 B0=n243 Y=n592
XU436 NAND2BX1 $PINS AN=n147 B=FE_OCPN6221_n148 Y=n16
XU437 NAND2X2 $PINS A=n115 B=n127 Y=n113
XU438 ADDFHX1 $PINS A=n419 B=FE_OFN6140_n2468 CI=n414 S=n412 CO=n411
XU439 ADDFX2 $PINS A=n453 B=n382 CI=FE_OFN6140_n2468 S=n402 CO=n401
XU441 XOR2X1 $PINS A=FE_OFN5894_r2236_DIFF_1 B=n456 Y=n436
XU442 INVX1 $PINS A=n543 Y=n435
XU443 NAND2XL $PINS A=FE_OFN5894_r2236_DIFF_1 B=n456 Y=n543
XU446 ADDFX2 $PINS A=FE_OFN168_r2236_DIFF_3 B=n457 CI=n436 S=n434 CO=n433
XU447 OR2X2 $PINS A=n392 B=n399 Y=n588
XU448 INVX1 $PINS A=n183 Y=n181
XU449 NAND2X1 $PINS A=n430 B=n433 Y=n559
XU450 NAND2X1 $PINS A=n400 B=n405 Y=n189
XU451 ADDFX2 $PINS A=n407 B=n449 CI=n402 S=n400 CO=n399
XU453 XOR2X1 $PINS A=n149 B=n16 Y=product[21]
XU455 ADDFX2 $PINS A=FE_OFN5726_r2236_DIFF_7 B=n451 CI=a[13] S=n342 CO=n341
XU456 XNOR2X4 $PINS A=FE_OCPN6226_n1 B=n576 Y=product[27]
XU458 OAI21X4 $PINS A0=n113 A1=n141 B0=n114 Y=n1
XU459 ADDFX2 $PINS A=a[0] B=n456 CI=FE_OFN168_r2236_DIFF_3 S=n428 CO=n427
XU460 OR2X2 $PINS A=FE_OFN168_r2236_DIFF_3 B=n440 Y=n596
XU462 ADDHXL $PINS A=FE_OFN5915_r2236_DIFF_2 B=n457 S=n432 CO=n431
XU463 INVX4 $PINS A=n476 Y=n457
XU465 ADDFX2 $PINS A=a[11] B=n447 CI=a[20] S=n312 CO=n311
XU466 ADDFX2 $PINS A=FE_OFN6140_n2468 B=n449 CI=n388 S=n386 CO=n385
XU468 CMPR32X1 $PINS A=n449 B=a[16] C=a[13] S=n299 CO=n298
XU469 ADDFHX2 $PINS A=n401 B=n394 CI=n448 S=n392 CO=n391
XU472 ADDFX2 $PINS A=a[4] B=FE_OFN5726_r2236_DIFF_7 CI=n451 S=n366 CO=n365
XU473 ADDFX2 $PINS A=n349 B=n445 CI=n342 S=n340 CO=n339
XU475 NAND2X1 $PINS A=n546 B=n69 Y=n67
XU476 ADDFX2 $PINS A=a[20] B=n333 CI=n326 S=n324 CO=n323
XU477 ADDFHX2 $PINS A=n341 B=n444 CI=n334 S=n332 CO=n331
XU478 ADDFHX2 $PINS A=n444 B=n355 CI=n348 S=n346 CO=n345
XU479 ADDFHX2 $PINS A=a[20] B=n464 CI=n340 S=n338 CO=n337
XU480 INVX1 $PINS A=n207 Y=n574
XU482 NOR2XL $PINS A=a[1] B=a[0] Y=n244
XU483 NAND2X1 $PINS A=n593 B=n595 Y=n59
XU484 NAND2X1 $PINS A=n554 B=n125 Y=n121
XU486 INVX1 $PINS A=n122 Y=n257
XU487 XOR2X1 $PINS A=n140 B=n575 Y=product[23]
XU488 XOR2X2 $PINS A=n98 B=n581 Y=product[29]
XU489 XNOR2X1 $PINS A=n284 B=n283 Y=n580
XU490 NOR2X2 $PINS A=n147 B=n144 Y=n142
XU491 NOR2X1 $PINS A=n328 B=n335 Y=n138
XU492 NOR2X1 $PINS A=n438 B=n439 Y=n231
XU493 OAI2BB2X4 $PINS A0N=n320 A1N=n327 B0=n133 B1=n139 Y=n128
XU494 OAI2BB2X1 $PINS A0N=n438 A1N=n439 B0=n233 B1=n231 Y=n230
XU495 XOR2X2 $PINS A=n76 B=n6 Y=product[31]
XU496 OAI2BB1X2 $PINS A0N=n562 A1N=n574 B0=n196 Y=n194
XU499 NAND2BX1 $PINS AN=n48 B=n51 Y=n4
XU500 OAI21X4 $PINS A0=n185 A1=n173 B0=n174 Y=n172
XU501 AND2X2 $PINS A=n434 B=n437 Y=n227
XU502 AOI21X2 $PINS A0=n255 A1=n1 B0=n109 Y=n107
XU503 XNOR2X1 $PINS A=n320 B=n327 Y=n578
XU504 NAND2BX1 $PINS AN=a[3] B=n440 Y=n237
XU505 OR2X2 $PINS A=n68 B=n102 Y=n546
XU506 INVX1 $PINS A=n100 Y=n102
XU507 AOI21X2 $PINS A0=FE_DBTN153_n559 A1=n585 B0=n216 Y=n214
XU509 NAND2BX1 $PINS AN=n571 B=n167 Y=n19
XU510 XOR3X2 $PINS A=FE_OFN378_r2236_DIFF_2 B=FE_OFN5835_N1281 C=n244
+ Y=product[4]
XU511 NAND2BX1 $PINS AN=n43 B=n44 Y=n3
XU512 XNOR2X2 $PINS A=n190 B=n23 Y=product[14]
XU513 NOR2X1 $PINS A=n307 B=n303 Y=n110
XU514 AND2X2 $PINS A=n418 B=n421 Y=n203
XU515 XNOR3X2 $PINS A=n438 B=n439 C=n233 Y=product[6]
XU516 AOI21X1 $PINS A0=n95 A1=n594 B0=n86 Y=n80
XU517 INVX1 $PINS A=n93 Y=n95
XU518 NAND2X1 $PINS A=n328 B=n335 Y=n139
XU519 NAND2X1 $PINS A=n406 B=n411 Y=n192
XU520 NAND2BX1 $PINS AN=n169 B=n170 Y=n20
XU521 NAND2BX1 $PINS AN=n122 B=n128 Y=n554
XU522 NAND2BX1 $PINS AN=n105 B=n106 Y=n579
XU523 OAI21XL $PINS A0=n59 A1=n80 B0=n60 Y=n58
XU524 XNOR3X2 $PINS A=n207 B=n418 C=n421 Y=product[11]
XU525 XNOR3X2 $PINS A=n413 B=FE_OFN5801_r2236_DIFF_9 C=n408 Y=n406
XU526 NOR2X2 $PINS A=n368 B=n375 Y=n571
XU527 XOR2X1 $PINS A=n201 B=n25 Y=product[12]
XU528 XNOR3X2 $PINS A=n430 B=n433 C=n225 Y=product[8]
XU529 NAND2BX1 $PINS AN=n117 B=n118 Y=n11
XU530 OAI221XL $PINS A0=n56 A1=n561 B0=n43 B1=n51 C0=n44 Y=n38
XU531 NAND3X1 $PINS A=n557 B=n555 C=n556 Y=n405
XU532 NOR2X1 $PINS A=n101 B=n92 Y=n90
XU533 INVX1 $PINS A=n99 Y=n101
XU534 XOR3X2 $PINS A=FE_OFN168_r2236_DIFF_3 B=n440 C=n592 Y=product[5]
XU535 NAND2X1 $PINS A=n313 B=n308 Y=n118
XU536 NAND2BX1 $PINS AN=n191 B=n192 Y=n24
XU537 XOR3X2 $PINS A=n434 B=n437 C=n230 Y=product[7]
XU538 AOI22X1 $PINS A0=n284 A1=n283 B0=n73 B1=n595 Y=n60
XU539 INVX1 $PINS A=n75 Y=n73
XU540 AOI21X2 $PINS A0=n140 A1=n127 B0=n128 Y=n126
XU541 ADDFX2 $PINS A=a[6] B=FE_OFN5801_r2236_DIFF_9 CI=n357 S=n350 CO=n349
XU542 INVX2 $PINS A=n463 Y=n442
XU543 NAND2X1 $PINS A=n371 B=n364 Y=n548
XU544 XOR2X2 $PINS A=n89 B=n7 Y=product[30]
XU545 ADDFX2 $PINS A=n311 B=n305 CI=n309 S=n303 CO=n302
XU546 INVX1 $PINS A=n218 Y=n216
XU548 AOI21X4 $PINS A0=n597 A1=n230 B0=n227 Y=n225
XU550 OAI21X1 $PINS A0=n117 A1=n125 B0=n118 Y=n116
XU552 OAI21X1 $PINS A0=n571 A1=n170 B0=n167 Y=n165
XU553 ADDFHX1 $PINS A=n427 B=n424 CI=n453 S=n422 CO=n421
XU554 INVX1 $PINS A=FE_OFN6137_r2236_DIFF_8 Y=n453
XU555 NOR2X1 $PINS A=n571 B=n169 Y=n164
XU556 NAND2X1 $PINS A=n392 B=n399 Y=n183
XU557 AOI21X4 $PINS A0=n212 A1=n591 B0=n209 Y=n207
XU558 XOR3X4 $PINS A=n364 B=n371 C=n446 Y=n362
XU559 NAND2X1 $PINS A=n446 B=n364 Y=n547
XU560 NAND2X1 $PINS A=n371 B=n446 Y=n549
XU561 NAND3X1 $PINS A=n549 B=n547 C=n548 Y=n361
XU562 ADDFHX2 $PINS A=n373 B=n366 CI=n448 S=n364 CO=n363
XU564 ADDFHX2 $PINS A=n443 B=n361 CI=n354 S=n352 CO=n351
XU565 XOR3X4 $PINS A=n316 B=n321 C=n323 Y=n314
XU566 NAND2XL $PINS A=n321 B=n316 Y=n551
XU567 NAND2X1 $PINS A=n321 B=n323 Y=n552
XU568 NAND3X1 $PINS A=n552 B=n550 C=n551 Y=n313
XU569 ADDFHX2 $PINS A=n318 B=n325 CI=n463 S=n316 CO=n315
XU570 ADDFHX2 $PINS A=n443 B=n331 CI=n442 S=n322 CO=n321
XU571 AOI21X1 $PINS A0=n1 A1=n77 B0=n78 Y=n76
XU572 AOI21X1 $PINS A0=n1 A1=n90 B0=n91 Y=n89
XU573 OAI21XL $PINS A0=n56 A1=n48 B0=n51 Y=n47
XU574 ADDFXL $PINS A=n445 B=FE_OFN5940_n5254 CI=n463 S=n285 CO=n284
XU575 ADDFX2 $PINS A=FE_OFN269_r2236_DIFF_11 B=n452 CI=n396 S=n394 CO=n393
XU576 ADDFX2 $PINS A=a[3] B=a[6] CI=n381 S=n374 CO=n373
XU579 INVX1 $PINS A=n200 Y=n198
XU580 ADDFX2 $PINS A=n390 B=n454 CI=FE_OFN269_r2236_DIFF_11 S=n408 CO=n407
XU582 ADDFX2 $PINS A=FE_OFN5801_r2236_DIFF_9 B=FE_OFN6104_r2236_DIFF_12
+ CI=FE_OFN5940_n5254 S=n326 CO=n325
XU583 ADDFX2 $PINS A=FE_OFN6104_r2236_DIFF_12 B=n447
+ CI=FE_OFN5772_r2236_DIFF_17 S=n295 CO=n294
XU584 NAND2X1 $PINS A=n584 B=n588 Y=n173
XU585 ADDFHX2 $PINS A=n385 B=n378 CI=n446 S=n376 CO=n375
XU586 ADDFHX2 $PINS A=n393 B=FE_OFN5908_r2236_DIFF_14 CI=n386 S=n384 CO=n383
XU587 ADDFX2 $PINS A=FE_OFN6137_r2236_DIFF_8 B=a[11] CI=n447 S=n334 CO=n333
XU588 ADDFX2 $PINS A=n423 B=n420 CI=n452 S=n418 CO=n417
XU589 NAND2BX1 $PINS AN=n79 B=n593 Y=n68
XU590 AOI21X1 $PINS A0=n82 A1=n593 B0=n73 Y=n69
XU591 INVX1 $PINS A=n80 Y=n82
XU592 CLKINVX3 $PINS A=n172 Y=n171
XU594 ADDFX2 $PINS A=FE_OFN5908_r2236_DIFF_14 B=n363 CI=n356 S=n354 CO=n353
XU595 OR2X2 $PINS A=n418 B=n421 Y=n589
XU596 OR2X2 $PINS A=n412 B=n417 Y=n586
XU598 NAND2X1 $PINS A=n422 B=n425 Y=n211
XU600 XOR2X1 $PINS A=n179 B=n21 Y=product[16]
XU601 INVX1 $PINS A=n156 Y=n154
XU602 ADDFHX2 $PINS A=n332 B=n337 CI=n330 S=n328 CO=n327
XU603 NAND2X2 $PINS A=n314 B=n319 Y=n125
XU604 NOR2X1 $PINS A=n101 B=n79 Y=n77
XU605 NOR2X1 $PINS A=n110 B=n105 Y=n99
XU607 NAND2X1 $PINS A=n336 B=n343 Y=n145
XU608 AOI21X1 $PINS A0=n57 A1=n100 B0=n58 Y=n56
XU609 NAND2X1 $PINS A=n57 B=n99 Y=n55
XU610 ADDFHX2 $PINS A=FE_OFN378_r2236_DIFF_2 B=FE_OFN5650_r2236_DIFF_5 CI=n389
+ S=n382 CO=n381
XU612 ADDFX2 $PINS A=n435 B=n572 CI=n432 S=n430 CO=n429
XU613 ADDFX2 $PINS A=n398 B=n572 CI=n453 S=n414 CO=n413
XU614 NAND2X1 $PINS A=n368 B=n375 Y=n167
XU615 OAI21X1 $PINS A0=n193 A1=n191 B0=n192 Y=n190
XU617 NAND2X1 $PINS A=n585 B=n590 Y=n213
XU618 XNOR2X2 $PINS A=n184 B=n22 Y=product[15]
XU619 ADDFXL $PINS A=a[16] B=FE_OFN5772_r2236_DIFF_17 CI=n441 S=n283 CO=n282
XU620 INVX2 $PINS A=n185 Y=n184
XU621 NOR2BXL $PINS AN=n127 B=n122 Y=n120
XU622 ADDFHX2 $PINS A=n449 B=n372 CI=n445 S=n370 CO=n369
XU623 ADDFHX2 $PINS A=FE_OFN5801_r2236_DIFF_9 B=n374 CI=n379 S=n372 CO=n371
XU624 NAND2XL $PINS A=n452 B=n413 Y=n555
XU625 NAND2XL $PINS A=n408 B=n413 Y=n556
XU626 NAND2XL $PINS A=n408 B=n452 Y=n557
XU627 NOR2X1 $PINS A=n406 B=n411 Y=n191
XU628 XOR2X2 $PINS A=n157 B=n17 Y=product[20]
XU629 XOR2X1 $PINS A=n162 B=n582 Y=product[19]
XU630 ADDFX2 $PINS A=n451 B=a[16] CI=a[13] S=n318 CO=n317
XU632 OAI21X1 $PINS A0=n188 A1=n192 B0=n189 Y=n187
XU633 INVX1 $PINS A=n211 Y=n209
XU634 NOR2X1 $PINS A=n101 B=n68 Y=n66
XU635 NOR2X1 $PINS A=n55 B=n48 Y=n46
XU636 INVX1 $PINS A=n88 Y=n86
XU637 OAI21X2 $PINS A0=FE_OCPN6221_n148 A1=n144 B0=n145 Y=n143
XU640 ADDFX2 $PINS A=FE_OFN5650_r2236_DIFF_5 B=FE_OFN6137_r2236_DIFF_8 CI=a[11]
+ S=n358 CO=n357
XU642 ADDFX2 $PINS A=FE_OFN5726_r2236_DIFF_7 B=n390 CI=n395 S=n388 CO=n387
XU643 ADDFHX1 $PINS A=FE_OFN6137_r2236_DIFF_8 B=n382 CI=FE_OFN269_r2236_DIFF_11
+ S=n380 CO=n379
XU644 ADDFX2 $PINS A=n358 B=n365 CI=n445 S=n356 CO=n355
XU645 AOI21X1 $PINS A0=n586 A1=n203 B0=n198 Y=n196
XU646 ADDFX2 $PINS A=n446 B=a[18] CI=n294 S=n289 CO=n288
XU647 ADDFX2 $PINS A=n298 B=n441 CI=n295 S=n293 CO=n292
XU648 NAND2X2 $PINS A=n376 B=n383 Y=n170
XU649 NOR2X1 $PINS A=n400 B=n405 Y=n188
XU650 ADDFX2 $PINS A=FE_OFN6104_r2236_DIFF_12 B=n350 CI=n446 S=n348 CO=n347
XU651 INVX1 $PINS A=n110 Y=n255
XU652 INVX1 $PINS A=n111 Y=n109
XU653 INVX1 $PINS A=n55 Y=n53
XU654 NAND2X1 $PINS A=n588 B=n183 Y=n22
XU655 XOR2X1 $PINS A=n45 B=n3 Y=product[34]
XU656 AOI21X1 $PINS A0=FE_OCPN6226_n1 A1=n46 B0=n47 Y=n45
XU657 NAND2X1 $PINS A=n583 B=n156 Y=n17
XU658 NAND2BX1 $PINS AN=n144 B=n145 Y=n15
XU659 AND2X2 $PINS A=FE_DBTN155_n138 B=n139 Y=n575
XU660 OR2X2 $PINS A=n43 B=n48 Y=n561
XU662 AND2X2 $PINS A=n586 B=n589 Y=n562
XU664 NAND2X1 $PINS A=n94 B=n594 Y=n79
XU665 AOI21X1 $PINS A0=n1 A1=n53 B0=n54 Y=n52
XU666 CLKINVX3 $PINS A=a[21] Y=n441
XU667 AND2X2 $PINS A=n587 B=n161 Y=n582
XU668 OAI21X4 $PINS A0=n171 A1=n169 B0=n170 Y=n168
XU669 XOR2X2 $PINS A=n65 B=n580 Y=product[32]
XU670 XOR2X1 $PINS A=n52 B=n4 Y=product[33]
XU671 ADDFHX1 $PINS A=a[1] B=n457 CI=n572 S=n424 CO=n423
XU673 NAND2X1 $PINS A=n268 B=n189 Y=n23
XU674 AOI21X1 $PINS A0=n1 A1=n66 B0=n67 Y=n65
XU675 NAND2X1 $PINS A=n583 B=n587 Y=n151
XU676 NAND2X1 $PINS A=n307 B=n303 Y=n111
XU677 NAND2X1 $PINS A=n384 B=n391 Y=n178
XU678 ADDFHX2 $PINS A=n347 B=n338 CI=n345 S=n336 CO=n335
XU679 XNOR2X2 $PINS A=n168 B=n19 Y=product[18]
XU680 NOR2X1 $PINS A=n188 B=n191 Y=n186
XU681 INVX1 $PINS A=n188 Y=n268
XU682 AOI21X4 $PINS A0=n186 A1=n194 B0=n187 Y=n185
XU683 XOR2X1 $PINS A=n171 B=n20 Y=product[17]
XU684 OAI21X4 $PINS A0=n149 A1=n147 B0=FE_OCPN6221_n148 Y=n146
XU685 XOR2X2 $PINS A=n193 B=n24 Y=product[13]
XU686 ADDFHX2 $PINS A=FE_OFN5908_r2236_DIFF_14 B=n377 CI=n370 S=n368 CO=n367
XU687 ADDFX2 $PINS A=FE_OFN5835_N1281 B=FE_OFN5915_r2236_DIFF_2 CI=n476 S=n438
+ CO=n437
XU688 AOI21X2 $PINS A0=n120 A1=n140 B0=n121 Y=n119
XU689 AOI21X1 $PINS A0=n184 A1=n588 B0=n181 Y=n179
XU690 INVX4 $PINS A=n150 Y=n149
XU691 NOR2X2 $PINS A=n336 B=n343 Y=n144
XU692 ADDFHX2 $PINS A=n353 B=n442 CI=n346 S=n344 CO=n343
XU693 AOI21X1 $PINS A0=n574 A1=n589 B0=n203 Y=n201
XU694 AOI21X1 $PINS A0=n596 A1=n592 B0=n235 Y=n233
XU695 ADDFX2 $PINS A=n449 B=FE_OFN5940_n5254 CI=a[18] S=n305 CO=n304
XU696 NOR2X1 $PINS A=n79 B=n59 Y=n57
XU697 ADDFHX2 $PINS A=a[1] B=n476 CI=n397 S=n390 CO=n389
XU698 AOI21X4 $PINS A0=n162 A1=n587 B0=FE_DBTN154_n161 Y=n157
XU699 OAI21X4 $PINS A0=n213 A1=n225 B0=n214 Y=n212
XU700 CMPR22X1 $PINS A=FE_OFN5894_r2236_DIFF_1 B=FE_OFN5915_r2236_DIFF_2 S=n440
+ CO=n439
XU701 XOR2X2 $PINS A=n219 B=n28 Y=product[9]
XU702 NOR2X2 $PINS A=n376 B=n383 Y=n169
XU703 AOI21X1 $PINS A0=n584 A1=n181 B0=n176 Y=n174
XU704 NOR2X1 $PINS A=n296 B=n293 Y=n92
XU705 NAND2X1 $PINS A=n296 B=n293 Y=n93
XU706 XNOR2X4 $PINS A=n146 B=n15 Y=product[22]
XU707 OR2X2 $PINS A=n434 B=n437 Y=n597
XU708 ADDFHX2 $PINS A=n442 B=n315 CI=n310 S=n308 CO=n307
XU709 ADDFX2 $PINS A=FE_OFN378_r2236_DIFF_2 B=n456 CI=n454 S=n420 CO=n419
XU710 NAND2XL $PINS A=FE_OFN378_r2236_DIFF_2 B=FE_OFN5835_N1281 Y=n243
XU711 ADDFX2 $PINS A=n398 B=a[6] CI=n381 S=n396 CO=n395
XU712 NAND2XL $PINS A=n586 B=n200 Y=n25
XU713 NAND2XL $PINS A=n585 B=n218 Y=n28
XU714 NAND2X1 $PINS A=n255 B=n111 Y=n576
XU715 NAND2XL $PINS A=n257 B=n125 Y=n577
XU716 XOR2X2 $PINS A=n135 B=n578 Y=product[24]
XU717 OR2X4 $PINS A=n384 B=n391 Y=n584
XU718 XOR2X4 $PINS A=n107 B=n579 Y=product[28]
XU719 NAND2XL $PINS A=n594 B=n88 Y=n7
XU720 NAND2XL $PINS A=n593 B=n75 Y=n6
XU721 NAND2XL $PINS A=n94 B=n93 Y=n581
XU722 ADDFHX2 $PINS A=n387 B=n380 CI=n448 S=n378 CO=n377
XU723 ADDFHX2 $PINS A=n339 B=n463 CI=n443 S=n330 CO=n329
XU724 INVX1 $PINS A=n178 Y=n176
XU725 OAI21XL $PINS A0=n102 A1=n79 B0=n80 Y=n78
XU726 NAND2X1 $PINS A=n584 B=n178 Y=n21
XU728 INVXL $PINS A=n139 Y=n137
XU729 XNOR2X1 $PINS A=n212 B=n27 Y=product[10]
XU730 NAND2X1 $PINS A=n591 B=n211 Y=n27
XU731 INVX1 $PINS A=n56 Y=n54
XU732 OR2X4 $PINS A=n352 B=n359 Y=n583
XU733 OR2X4 $PINS A=n360 B=n367 Y=n587
XU734 OAI21XL $PINS A0=n102 A1=n92 B0=n93 Y=n91
XU735 NAND2X1 $PINS A=n412 B=n417 Y=n200
XU736 NAND2X1 $PINS A=n352 B=n359 Y=n156
XU737 AOI21XL $PINS A0=n1 A1=n37 B0=n38 Y=n36
XU738 NOR2XL $PINS A=n55 B=n561 Y=n37
XU739 INVX1 $PINS A=n92 Y=n94
XU741 OR2X2 $PINS A=n422 B=n425 Y=n591
XU742 NOR2XL $PINS A=n282 B=n443 Y=n48
XU743 OR2X2 $PINS A=n285 B=n288 Y=n593
XU744 OR2X2 $PINS A=n289 B=n292 Y=n594
XU745 OR2X2 $PINS A=n284 B=n283 Y=n595
XU746 NAND2X1 $PINS A=n302 B=n297 Y=n106
XU747 NAND2X1 $PINS A=n289 B=n292 Y=n88
XU748 NAND2X1 $PINS A=n285 B=n288 Y=n75
XU749 XOR2X1 $PINS A=n36 B=n2 Y=product[35]
XU750 NAND2X1 $PINS A=n599 B=n35 Y=n2
XU752 OR2XL $PINS A=FE_OFN378_r2236_DIFF_2 B=FE_OFN5835_N1281 Y=n598
XU753 ADDFX2 $PINS A=n299 B=n463 CI=n304 S=n297 CO=n296
XU754 NAND2XL $PINS A=a[18] B=n441 Y=n35
XU755 OR2XL $PINS A=a[18] B=n441 Y=n599
XU756 ADDHXL $PINS A=a[0] B=a[3] S=n398 CO=n397
XU757 INVX4 $PINS A=n141 Y=n140
XU758 NAND2XL $PINS A=n463 B=n443 Y=n44
XU759 NOR2XL $PINS A=n463 B=n443 Y=n43
XU760 NAND2XL $PINS A=n282 B=n443 Y=n51
XU761 XOR2XL $PINS A=a[1] B=a[0] Y=product[3]
XU762 NAND2BX1 $PINS AN=n430 B=n619 Y=n590
XU764 AOI2BB1X1 $PINS A0N=n225 A1N=n620 B0=FE_DBTN153_n559 Y=n219
XU765 INVX1 $PINS A=n590 Y=n620
.ENDS

.SUBCKT CONV_DW01_add_37 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XFE_OCPC2323_N1731 BUFX3 $PINS A=B[20] Y=FE_OCPN6227_N1731
XFE_OFC2156_n51 INVX2 $PINS A=n51 Y=n49
XFE_OFC2105_n172 CLKINVX3 $PINS A=n171 Y=FE_OFN6084_n172
XFE_OFC2104_n172 CLKINVX3 $PINS A=n172 Y=n171
XFE_OFC1879_n54 INVX1 $PINS A=n56 Y=FE_OFN5926_n54
XFE_OFC1878_n54 CLKINVX3 $PINS A=n54 Y=n56
XFE_OFC854_n181 INVX1 $PINS A=n181 Y=n180
XFE_OFC819_n90 INVX8 $PINS A=n90 Y=FE_OFN207_n90
XFE_DBTC152_n153 INVX2 $PINS A=n153 Y=FE_DBTN152_n153
XU6 XOR2X4 $PINS A=n41 B=n2 Y=SUM[34]
XU10 NOR2X2 $PINS A=B[34] B=A[34] Y=n39
XU12 XNOR2X4 $PINS A=n46 B=n3 Y=SUM[33]
XU18 NOR2X4 $PINS A=B[33] B=A[33] Y=n44
XU20 XNOR2X4 $PINS A=n53 B=n4 Y=SUM[32]
XU22 NAND2X2 $PINS A=n49 B=n56 Y=n47
XU28 NOR2X2 $PINS A=B[32] B=A[32] Y=n51
XU42 OAI21X4 $PINS A0=n90 A1=n62 B0=n63 Y=n61
XU45 NOR2X4 $PINS A=n66 B=n71 Y=n64
XU49 NOR2X4 $PINS A=B[30] B=A[30] Y=n66
XU51 XOR2X4 $PINS A=n75 B=n7 Y=SUM[29]
XU59 NOR2X2 $PINS A=A[29] B=B[29] Y=n71
XU61 XOR2X4 $PINS A=n84 B=n8 Y=SUM[28]
XU67 NOR2X4 $PINS A=n87 B=n82 Y=n76
XU68 OAI21X4 $PINS A0=n82 A1=n88 B0=n83 Y=n77
XU71 NOR2X4 $PINS A=A[28] B=B[28] Y=n82
XU83 AOI21X4 $PINS A0=n99 A1=n91 B0=n92 Y=n90
XU84 NOR2X2 $PINS A=n93 B=n96 Y=n91
XU91 OAI21X2 $PINS A0=n98 A1=n96 B0=n97 Y=n95
XU94 NOR2X2 $PINS A=B[25] B=A[25] Y=n96
XU95 NAND2X2 $PINS A=B[25] B=A[25] Y=n97
XU98 OAI21X4 $PINS A0=n112 A1=n100 B0=n101 Y=n99
XU107 XNOR2X2 $PINS A=n111 B=n13 Y=SUM[23]
XU117 AOI21X4 $PINS A0=n121 A1=n113 B0=n114 Y=n112
XU118 NOR2X2 $PINS A=n115 B=n118 Y=n113
XU119 OAI21X2 $PINS A0=n115 A1=n119 B0=n116 Y=n114
XU125 OAI21X2 $PINS A0=n120 A1=n118 B0=n119 Y=n117
XU128 NOR2X2 $PINS A=B[21] B=A[21] Y=n118
XU129 NAND2X2 $PINS A=B[21] B=A[21] Y=n119
XU132 OAI21X4 $PINS A0=n122 A1=n139 B0=n123 Y=n121
XU134 AOI21X2 $PINS A0=n410 A1=n130 B0=n125 Y=n123
XU147 NOR2X1 $PINS A=B[19] B=A[19] Y=n131
XU207 AOI21X1 $PINS A0=n181 A1=n173 B0=n174 Y=n172
XU294 ADDFX2 $PINS A=B[1] B=n228 CI=A[1] S=SUM[1] CO=n227
XU306 NOR2X2 $PINS A=A[22] B=B[22] Y=n115
XU307 INVX1 $PINS A=n105 Y=n103
XU308 NAND2X2 $PINS A=n393 B=n411 Y=n100
XU309 NAND2BX1 $PINS AN=n66 B=n67 Y=n403
XU311 INVX1 $PINS A=n88 Y=n388
XU312 OAI21X2 $PINS A0=n44 A1=n48 B0=n45 Y=n43
XU313 INVX1 $PINS A=n198 Y=n196
XU314 XOR2X2 $PINS A=n188 B=n26 Y=SUM[10]
XU315 NAND3XL $PINS A=n139 B=n390 C=n137 Y=n392
XU316 INVX4 $PINS A=n139 Y=n138
XU317 NAND2X1 $PINS A=B[24] B=A[24] Y=n105
XU318 NAND2X1 $PINS A=n106 B=n383 Y=n384
XU319 NAND2X1 $PINS A=n382 B=n404 Y=n385
XU320 NAND2X2 $PINS A=n384 B=n385 Y=SUM[24]
XU321 INVX1 $PINS A=n106 Y=n382
XU322 INVXL $PINS A=n404 Y=n383
XU323 NOR2X1 $PINS A=n158 B=n152 Y=n386
XU325 OR2X2 $PINS A=n386 B=FE_DBTN152_n153 Y=n151
XU326 XNOR2X4 $PINS A=n151 B=n20 Y=SUM[16]
XU327 INVX1 $PINS A=n131 Y=n400
XU328 AOI21X2 $PINS A0=FE_OFN207_n90 A1=n85 B0=n388 Y=n84
XU329 XOR2X1 $PINS A=n133 B=n17 Y=SUM[19]
XU330 NAND2XL $PINS A=n413 B=n187 Y=n26
XU331 INVX1 $PINS A=n187 Y=n185
XU332 NAND2X1 $PINS A=A[10] B=B[10] Y=n187
XU333 XOR2X2 $PINS A=n117 B=n408 Y=SUM[22]
XU334 NAND2X2 $PINS A=n413 B=n415 Y=n182
XU335 INVX1 $PINS A=n170 Y=n168
XU336 OAI2BB1X1 $PINS A0N=n420 A1N=n213 B0=n212 Y=n417
XU337 NAND2X1 $PINS A=B[19] B=A[19] Y=n132
XU339 AOI21X2 $PINS A0=n171 A1=n414 B0=n168 Y=n166
XU340 NAND2X1 $PINS A=A[13] B=B[13] Y=n170
XU341 NAND2X1 $PINS A=A[8] B=B[8] Y=n198
XU342 AOI21X1 $PINS A0=n421 A1=n419 B0=n218 Y=n216
XU343 NAND2X1 $PINS A=B[26] B=A[26] Y=n94
XU345 XNOR2X2 $PINS A=n144 B=n19 Y=SUM[17]
XU346 NAND2X1 $PINS A=n391 B=n392 Y=SUM[18]
XU347 NAND2X2 $PINS A=A[23] B=B[23] Y=n110
XU348 XOR2X2 $PINS A=n177 B=n405 Y=SUM[12]
XU349 NAND2X2 $PINS A=B[34] B=A[34] Y=n40
XU350 NOR2X1 $PINS A=n175 B=n178 Y=n173
XU351 AOI21X4 $PINS A0=FE_OFN207_n90 A1=n76 B0=n77 Y=n75
XU352 OAI21X1 $PINS A0=n175 A1=n179 B0=n176 Y=n174
XU353 OAI21X2 $PINS A0=n66 A1=n74 B0=n67 Y=n65
XU355 INVX1 $PINS A=n52 Y=n50
XU356 XNOR2X4 $PINS A=n95 B=n10 Y=SUM[26]
XU357 NAND3BX2 $PINS AN=n131 B=n410 C=n390 Y=n122
XU358 NAND2X2 $PINS A=n56 B=n55 Y=n406
XU359 NOR2BX1 $PINS AN=n176 B=n175 Y=n405
XU360 INVX2 $PINS A=n55 Y=n57
XU361 NAND2BX4 $PINS AN=n39 B=n40 Y=n2
XU362 NOR2BX1 $PINS AN=n88 B=n87 Y=n401
XU363 NOR2BX1 $PINS AN=n412 B=n170 Y=n389
XU364 AOI21X4 $PINS A0=n108 A1=n393 B0=n103 Y=n101
XU365 OAI21X4 $PINS A0=n60 A1=FE_OFN5926_n54 B0=n55 Y=n53
XU366 AOI31X1 $PINS A0=n138 A1=n400 A2=n390 B0=n130 Y=n128
XU367 OAI2BB1XL $PINS A0N=n390 A1N=n137 B0=n138 Y=n391
XU368 NAND2BX1 $PINS AN=n200 B=n201 Y=n29
XU369 NAND2BX2 $PINS AN=n44 B=n45 Y=n3
XU370 NAND2BX1 $PINS AN=n118 B=n119 Y=n15
XU371 AOI21X2 $PINS A0=n138 A1=n390 B0=n135 Y=n133
XU372 NAND2BX1 $PINS AN=n214 B=n215 Y=n32
XU373 NOR2X2 $PINS A=n44 B=n47 Y=n42
XU374 NOR2BX1 $PINS AN=n116 B=n115 Y=n408
XU375 OAI21XL $PINS A0=n214 A1=n216 B0=n215 Y=n213
XU376 NAND2BX1 $PINS AN=n142 B=n143 Y=n19
XU377 AOI21X1 $PINS A0=n111 A1=n411 B0=n108 Y=n106
XU378 CLKINVX3 $PINS A=n110 Y=n108
XU379 XOR2X2 $PINS A=n166 B=n22 Y=SUM[14]
XU380 NAND2BX1 $PINS AN=n96 B=n97 Y=n402
XU381 XNOR2X2 $PINS A=n38 B=n1 Y=SUM[35]
XU382 NAND2BX1 $PINS AN=n82 B=n83 Y=n8
XU383 INVX1 $PINS A=n150 Y=n148
XU385 XNOR2X2 $PINS A=n171 B=n23 Y=SUM[13]
XU387 OAI21X1 $PINS A0=n180 A1=n178 B0=n179 Y=n177
XU388 NAND2XL $PINS A=n255 B=n179 Y=n25
XU389 NOR2X2 $PINS A=A[11] B=B[11] Y=n178
XU390 NOR2X4 $PINS A=B[27] B=A[27] Y=n87
XU391 CLKINVX3 $PINS A=n159 Y=n158
XU392 OAI21X4 $PINS A0=n146 A1=n142 B0=n143 Y=n141
XU393 NAND2X1 $PINS A=A[17] B=B[17] Y=n143
XU394 INVX1 $PINS A=n112 Y=n111
XU395 NAND2X2 $PINS A=A[11] B=B[11] Y=n179
XU396 NOR2X2 $PINS A=n389 B=n163 Y=n161
XU397 NOR2X4 $PINS A=A[15] B=B[15] Y=n152
XU398 NAND2X1 $PINS A=n251 B=n153 Y=n21
XU399 INVXL $PINS A=n178 Y=n255
XU401 NAND2X2 $PINS A=n64 B=n76 Y=n62
XU402 AOI21X4 $PINS A0=n64 A1=n77 B0=n65 Y=n63
XU403 NAND2X1 $PINS A=n412 B=n414 Y=n160
XU404 INVX1 $PINS A=n127 Y=n125
XU405 INVX2 $PINS A=n77 Y=n79
XU406 NAND2X1 $PINS A=A[16] B=B[16] Y=n150
XU407 OAI21X2 $PINS A0=n200 A1=n202 B0=n201 Y=n199
XU408 OR2X2 $PINS A=A[8] B=B[8] Y=n416
XU409 NAND2X1 $PINS A=A[9] B=B[9] Y=n192
XU410 INVX1 $PINS A=n192 Y=n190
XU411 OR2X2 $PINS A=A[9] B=B[9] Y=n415
XU412 NAND2X1 $PINS A=n400 B=n132 Y=n17
XU413 INVX1 $PINS A=n87 Y=n85
XU414 NAND2X1 $PINS A=n49 B=n52 Y=n4
XU415 NAND2BX1 $PINS AN=n93 B=n94 Y=n10
XU416 NAND2X1 $PINS A=n422 B=n37 Y=n1
XU417 NAND2X1 $PINS A=B[35] B=A[35] Y=n37
XU418 OR2X2 $PINS A=A[18] B=B[18] Y=n390
XU419 INVX1 $PINS A=n71 Y=n237
XU420 AOI21X1 $PINS A0=n193 A1=n415 B0=n190 Y=n188
XU421 OAI21X4 $PINS A0=n41 A1=n39 B0=n40 Y=n38
XU422 AOI21X2 $PINS A0=n413 A1=n190 B0=n185 Y=n183
XU423 INVX2 $PINS A=n99 Y=n98
XU424 NAND2X2 $PINS A=A[29] B=B[29] Y=n74
XU425 INVX1 $PINS A=n165 Y=n163
XU427 NAND2X2 $PINS A=A[15] B=B[15] Y=n153
XU428 NAND2X4 $PINS A=B[31] B=A[31] Y=n55
XU429 NOR2X2 $PINS A=A[17] B=B[17] Y=n142
XU430 OR2X2 $PINS A=FE_OCPN6227_N1731 B=A[20] Y=n410
XU431 OAI21X4 $PINS A0=FE_OFN6084_n172 A1=n160 B0=n161 Y=n159
XU432 XOR2X2 $PINS A=n98 B=n402 Y=SUM[25]
XU433 XOR2X2 $PINS A=n120 B=n15 Y=SUM[21]
XU434 AOI21X4 $PINS A0=n49 A1=n57 B0=n50 Y=n48
XU435 INVX1 $PINS A=n152 Y=n251
XU436 OAI2BB1X1 $PINS A0N=n423 A1N=n227 B0=n226 Y=n419
XU437 NAND2X1 $PINS A=n409 B=n251 Y=n145
XU438 NAND2X1 $PINS A=A[14] B=B[14] Y=n165
XU439 AOI21X1 $PINS A0=n418 A1=n417 B0=n204 Y=n202
XU440 INVX1 $PINS A=n206 Y=n204
XU441 NAND2X1 $PINS A=A[7] B=B[7] Y=n201
XU442 NAND2X1 $PINS A=A[20] B=FE_OCPN6227_N1731 Y=n127
XU444 XOR2X2 $PINS A=n180 B=n25 Y=SUM[11]
XU445 NAND2X2 $PINS A=n237 B=n74 Y=n7
XU446 OR2X4 $PINS A=A[24] B=B[24] Y=n393
XU447 OR2X2 $PINS A=B[0] B=A[0] Y=n394
XU448 NAND2XL $PINS A=n414 B=n170 Y=n23
XU449 XOR2X2 $PINS A=FE_OFN207_n90 B=n401 Y=SUM[27]
XU450 XNOR2X2 $PINS A=n28 B=n199 Y=SUM[8]
XU451 XOR2XL $PINS A=n29 B=n202 Y=SUM[7]
XU452 OR2XL $PINS A=A[3] B=B[3] Y=n421
XU453 OAI21X2 $PINS A0=n93 A1=n97 B0=n94 Y=n92
XU454 NOR2X1 $PINS A=A[7] B=B[7] Y=n200
XU455 XOR2X1 $PINS A=n158 B=n21 Y=SUM[15]
XU456 INVX1 $PINS A=n121 Y=n120
XU457 OR2X2 $PINS A=A[13] B=B[13] Y=n414
XU458 OAI21X1 $PINS A0=n131 A1=n137 B0=n132 Y=n130
XU459 AOI21X2 $PINS A0=n416 A1=n199 B0=n196 Y=n194
XU460 OAI21X4 $PINS A0=n182 A1=n194 B0=n183 Y=n181
XU461 NAND2X1 $PINS A=A[22] B=B[22] Y=n116
XU462 AOI21X4 $PINS A0=n140 A1=n159 B0=n141 Y=n139
XU463 NOR2BX1 $PINS AN=n76 B=n71 Y=n69
XU464 NAND2X1 $PINS A=A[12] B=B[12] Y=n176
XU465 NOR2X2 $PINS A=B[31] B=A[31] Y=n54
XU466 XOR2X4 $PINS A=n60 B=n406 Y=SUM[31]
XU467 NAND2X1 $PINS A=B[30] B=A[30] Y=n67
XU468 OAI21X2 $PINS A0=n47 A1=n60 B0=n48 Y=n46
XU469 INVX8 $PINS A=n61 Y=n60
XU470 OAI21X1 $PINS A0=n158 A1=n145 B0=n146 Y=n144
XU471 AOI21X4 $PINS A0=n409 A1=FE_DBTN152_n153 B0=n148 Y=n146
XU472 OR2X4 $PINS A=A[16] B=B[16] Y=n409
XU473 NAND2X4 $PINS A=B[27] B=A[27] Y=n88
XU474 NOR2X2 $PINS A=B[26] B=A[26] Y=n93
XU475 NOR2X2 $PINS A=A[12] B=B[12] Y=n175
XU476 NOR2X2 $PINS A=n145 B=n142 Y=n140
XU477 NAND2XL $PINS A=A[4] B=B[4] Y=n215
XU478 OR2X2 $PINS A=A[6] B=B[6] Y=n418
XU479 INVX1 $PINS A=n220 Y=n218
XU480 NAND2X1 $PINS A=A[5] B=B[5] Y=n212
XU481 INVX1 $PINS A=n230 Y=n228
XU482 INVXL $PINS A=n137 Y=n135
XU483 INVX1 $PINS A=n194 Y=n193
XU484 XOR2X4 $PINS A=n68 B=n403 Y=SUM[30]
XU485 NAND2XL $PINS A=n393 B=n105 Y=n404
XU486 NAND2XL $PINS A=n416 B=n198 Y=n28
XU487 NAND2XL $PINS A=n418 B=n206 Y=n30
XU488 NAND2XL $PINS A=n415 B=n192 Y=n27
XU489 NAND2XL $PINS A=n412 B=n165 Y=n22
XU490 XNOR2X1 $PINS A=n31 B=n213 Y=SUM[5]
XU491 NAND2XL $PINS A=n420 B=n212 Y=n31
XU492 OR2X2 $PINS A=A[10] B=B[10] Y=n413
XU493 NAND2X2 $PINS A=B[32] B=A[32] Y=n52
XU494 NAND2XL $PINS A=n421 B=n220 Y=n33
XU495 NAND2XL $PINS A=n423 B=n226 Y=n34
XU496 NAND2XL $PINS A=A[2] B=B[2] Y=n226
XU497 AND2X1 $PINS A=n394 B=n230 Y=SUM[0]
XU498 XOR2X1 $PINS A=n128 B=n16 Y=SUM[20]
XU499 NAND2XL $PINS A=n127 B=n410 Y=n16
XU500 NAND2X2 $PINS A=A[18] B=B[18] Y=n137
XU501 NAND2XL $PINS A=n411 B=n110 Y=n13
XU502 NAND2XL $PINS A=n409 B=n150 Y=n20
XU503 OR2X4 $PINS A=A[23] B=B[23] Y=n411
XU504 XNOR2X1 $PINS A=n193 B=n27 Y=SUM[9]
XU505 XNOR2X1 $PINS A=n30 B=n417 Y=SUM[6]
XU506 XOR2X1 $PINS A=n32 B=n216 Y=SUM[4]
XU507 OR2X2 $PINS A=A[14] B=B[14] Y=n412
XU508 NOR2X1 $PINS A=A[4] B=B[4] Y=n214
XU509 NAND2X1 $PINS A=A[6] B=B[6] Y=n206
XU510 XNOR2X1 $PINS A=n33 B=n419 Y=SUM[3]
XU511 NAND2X2 $PINS A=B[33] B=A[33] Y=n45
XU512 NAND2X1 $PINS A=A[3] B=B[3] Y=n220
XU513 XNOR2X1 $PINS A=n34 B=n227 Y=SUM[2]
XU514 OR2X2 $PINS A=A[5] B=B[5] Y=n420
XU515 OR2X2 $PINS A=B[35] B=A[35] Y=n422
XU516 OR2X2 $PINS A=A[2] B=B[2] Y=n423
XU517 OAI21X1 $PINS A0=n79 A1=n71 B0=n74 Y=n70
XU518 AOI21X2 $PINS A0=n69 A1=FE_OFN207_n90 B0=n70 Y=n68
XU519 NAND2X2 $PINS A=B[28] B=A[28] Y=n83
XU521 AOI21X4 $PINS A0=n42 A1=n61 B0=n43 Y=n41
XU523 NAND2XL $PINS A=B[0] B=A[0] Y=n230
.ENDS

.SUBCKT CONV_DW01_add_38 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XFE_RC_650_0 OAI21X2 $PINS A0=n117 A1=n113 B0=n114 Y=n112
XFE_RC_517_0 AOI21X4 $PINS A0=n50 A1=n58 B0=n51 Y=n49
XFE_OFC2241_N1517 CLKBUFX8 $PINS A=A[26] Y=FE_OFN6161_N1517
XFE_OFC2188_N1515 CLKBUFX8 $PINS A=A[24] Y=FE_OFN6136_N1515
XFE_OFC2165_N1516 CLKBUFX8 $PINS A=A[25] Y=FE_OFN6113_N1516
XFE_OFC2005_N1756 BUFX3 $PINS A=B[9] Y=FE_OFN6033_N1756
XFE_OFC1984_N1507 BUFX4 $PINS A=A[16] Y=FE_OFN6012_N1507
XFE_OFC1978_N1754 BUFX3 $PINS A=B[7] Y=FE_OFN6006_N1754
XFE_OFC1949_N1510 CLKBUFX8 $PINS A=A[19] Y=FE_OFN5976_N1510
XFE_OFC1928_N1514 CLKBUFX8 $PINS A=A[23] Y=FE_OFN5955_N1514
XFE_OFC1922_N1513 CLKBUFX8 $PINS A=A[22] Y=FE_OFN5949_N1513
XFE_OFC1374_n130 INVXL $PINS A=n128 Y=FE_OFN5660_n130
XFE_OFC1373_n130 INVX1 $PINS A=n130 Y=n128
XFE_OFC483_n103 INVX1 $PINS A=n103 Y=n101
XU1 XNOR2X4 $PINS A=n40 B=n3 Y=SUM[35]
XU24 NOR2X4 $PINS A=B[33] B=A[33] Y=n52
XU34 NOR2X4 $PINS A=B[32] B=A[32] Y=n55
XU37 AOI21X4 $PINS A0=n61 A1=n97 B0=n62 Y=n1
XU38 NOR2X4 $PINS A=n63 B=n79 Y=n61
XU39 OAI21X4 $PINS A0=n397 A1=n63 B0=n64 Y=n62
XU40 NAND2X4 $PINS A=n65 B=n391 Y=n63
XU41 AOI21X4 $PINS A0=n65 A1=n388 B0=n417 Y=n64
XU46 NOR2X4 $PINS A=B[31] B=A[31] Y=n67
XU82 NOR2X2 $PINS A=B[28] B=A[28] Y=n90
XU83 NAND2X4 $PINS A=A[28] B=B[28] Y=n91
XU86 OAI21X4 $PINS A0=n110 A1=n98 B0=n99 Y=n97
XU88 AOI21X2 $PINS A0=n407 A1=n106 B0=n101 Y=n99
XU105 AOI21X4 $PINS A0=n119 A1=n111 B0=n112 Y=n110
XU110 NOR2X2 $PINS A=B[25] B=FE_OFN6113_N1516 Y=n113
XU116 NOR2X2 $PINS A=B[24] B=FE_OFN6136_N1515 Y=n116
XU120 OAI21X4 $PINS A0=n120 A1=n132 B0=n121 Y=n119
XU298 ADDFX2 $PINS A=B[1] B=n234 CI=A[1] S=SUM[1] CO=n231
XU308 XOR2X1 $PINS A=n1 B=n402 Y=SUM[32]
XU309 XOR2X1 $PINS A=n109 B=n401 Y=SUM[26]
XU311 NAND2X2 $PINS A=n92 B=n411 Y=n79
XU312 INVX2 $PINS A=n90 Y=n92
XU313 CLKINVX3 $PINS A=n44 Y=n42
XU314 AOI21X2 $PINS A0=n204 A1=n414 B0=n201 Y=n199
XU315 OAI21X1 $PINS A0=n96 A1=n90 B0=n91 Y=n89
XU316 NAND2X2 $PINS A=B[14] B=A[14] Y=n180
XU318 CLKINVX3 $PINS A=n168 Y=n170
XU319 AOI21X1 $PINS A0=n413 A1=n183 B0=n178 Y=n176
XU320 INVX1 $PINS A=n180 Y=n178
XU321 NAND2X1 $PINS A=B[8] B=A[8] Y=n206
XU323 NAND2X1 $PINS A=B[26] B=FE_OFN6161_N1517 Y=n108
XU324 OAI21XL $PINS A0=n173 A1=n160 B0=n161 Y=n159
XU325 INVXL $PINS A=n174 Y=n173
XU326 NAND2BX1 $PINS AN=n157 B=n158 Y=n21
XU327 NAND2BX1 $PINS AN=n138 B=n139 Y=n18
XU328 NAND2BX1 $PINS AN=n135 B=n136 Y=n17
XU329 NAND2BXL $PINS AN=n113 B=n114 Y=n13
XU330 OAI21X1 $PINS A0=n190 A1=n194 B0=n191 Y=n189
XU331 OAI2BB1X1 $PINS A0N=n385 A1N=n97 B0=n397 Y=n78
XU332 INVX1 $PINS A=n79 Y=n385
XU333 NAND2XL $PINS A=n57 B=n56 Y=n402
XU334 NAND2XL $PINS A=n255 B=n168 Y=n23
XU335 AOI21X1 $PINS A0=n186 A1=n416 B0=n183 Y=n181
XU336 INVXL $PINS A=n187 Y=n186
XU337 OAI21XL $PINS A0=n195 A1=n193 B0=n194 Y=n192
XU338 INVXL $PINS A=n196 Y=n195
XU339 NAND2BX1 $PINS AN=n388 B=n392 Y=n8
XU341 AOI21X1 $PINS A0=n82 A1=n392 B0=n388 Y=n71
XU343 INVX2 $PINS A=n53 Y=n51
XU344 INVX1 $PINS A=n203 Y=n201
XU345 XNOR2X1 $PINS A=n89 B=n9 Y=SUM[29]
XU346 INVX1 $PINS A=n167 Y=n255
XU347 OAI21XL $PINS A0=n140 A1=n138 B0=n139 Y=n137
XU348 INVX1 $PINS A=n141 Y=n140
XU349 AOI21X1 $PINS A0=n131 A1=n410 B0=n128 Y=n126
XU350 INVX1 $PINS A=n132 Y=n131
XU352 AOI21X1 $PINS A0=n419 A1=n228 B0=n225 Y=n223
XU353 INVX1 $PINS A=n227 Y=n225
XU354 XOR2X2 $PINS A=n69 B=n420 Y=SUM[31]
XU355 INVX1 $PINS A=n219 Y=n217
XU356 INVX1 $PINS A=n154 Y=n153
XU357 OR2X2 $PINS A=A[30] B=B[30] Y=n392
XU358 INVX1 $PINS A=n110 Y=n109
XU359 AND2X4 $PINS A=B[31] B=A[31] Y=n417
XU360 OAI21X2 $PINS A0=n70 A1=n96 B0=n71 Y=n69
XU361 INVX2 $PINS A=n411 Y=n404
XU362 AOI21X1 $PINS A0=n109 A1=n409 B0=n106 Y=n104
XU363 XOR2X1 $PINS A=n104 B=n11 Y=SUM[27]
XU364 INVX8 $PINS A=n52 Y=n50
XU365 NOR2X2 $PINS A=A[35] B=B[35] Y=n38
XU366 XNOR2X4 $PINS A=n54 B=n395 Y=SUM[33]
XU367 NAND2X2 $PINS A=B[34] B=A[34] Y=n46
XU368 INVX1 $PINS A=n397 Y=n82
XU369 NAND2X1 $PINS A=B[18] B=A[18] Y=n152
XU370 CLKINVX3 $PINS A=n56 Y=n58
XU371 NAND2X2 $PINS A=B[32] B=A[32] Y=n56
XU372 NAND2BX1 $PINS AN=n79 B=n392 Y=n70
XU373 NOR2X2 $PINS A=B[15] B=A[15] Y=n167
XU374 NAND2X1 $PINS A=B[17] B=A[17] Y=n158
XU375 NOR2X1 $PINS A=B[10] B=A[10] Y=n197
XU376 NAND2X2 $PINS A=B[35] B=A[35] Y=n39
XU377 XOR2X2 $PINS A=n47 B=n400 Y=SUM[34]
XU378 INVX1 $PINS A=n396 Y=n236
XU379 NAND2X2 $PINS A=B[15] B=A[15] Y=n168
XU380 NOR2X1 $PINS A=n190 B=n193 Y=n188
XU381 OR2X2 $PINS A=B[13] B=A[13] Y=n416
XU382 CLKINVX3 $PINS A=n55 Y=n57
XU383 OAI21X2 $PINS A0=n49 A1=n396 B0=n46 Y=n44
XU384 INVX1 $PINS A=n119 Y=n118
XU385 OR2X2 $PINS A=n396 B=n48 Y=n386
XU387 INVX1 $PINS A=n108 Y=n106
XU388 NAND2X1 $PINS A=B[10] B=A[10] Y=n198
XU389 OR2X4 $PINS A=B[18] B=A[18] Y=n405
XU390 AOI21XL $PINS A0=n153 A1=n405 B0=n150 Y=n148
XU391 INVX1 $PINS A=n152 Y=n150
XU392 NAND2X1 $PINS A=B[21] B=A[21] Y=n136
XU393 INVX1 $PINS A=n185 Y=n183
XU394 NAND2X1 $PINS A=B[27] B=A[27] Y=n103
XU395 AND2X2 $PINS A=n406 B=n405 Y=n393
XU396 NAND2X2 $PINS A=n394 B=n410 Y=n120
XU397 OAI21XL $PINS A0=n173 A1=n167 B0=n168 Y=n166
XU398 XNOR2X1 $PINS A=n159 B=n21 Y=SUM[17]
XU399 NAND2X1 $PINS A=B[22] B=FE_OFN5949_N1513 Y=n130
XU400 AND2X4 $PINS A=A[30] B=B[30] Y=n388
XU401 AND2X2 $PINS A=n399 B=n233 Y=SUM[0]
XU402 OR2X4 $PINS A=B[30] B=A[30] Y=n391
XU403 AOI21X1 $PINS A0=n418 A1=n220 B0=n217 Y=n215
XU404 NAND2BX4 $PINS AN=n154 B=n393 Y=n403
XU405 INVX1 $PINS A=n88 Y=n86
XU406 OR2X4 $PINS A=B[23] B=FE_OFN5955_N1514 Y=n394
XU407 NAND2X1 $PINS A=B[12] B=A[12] Y=n191
XU408 OR2X4 $PINS A=B[16] B=FE_OFN6012_N1507 Y=n412
XU409 NAND2XL $PINS A=n50 B=n53 Y=n395
XU410 OAI21XL $PINS A0=n221 A1=n223 B0=n222 Y=n220
XU411 NOR2X1 $PINS A=B[8] B=A[8] Y=n205
XU412 NAND2X2 $PINS A=n413 B=n416 Y=n175
XU413 NAND2XL $PINS A=n413 B=n180 Y=n24
XU414 OR2X4 $PINS A=B[14] B=A[14] Y=n413
XU415 OAI21X4 $PINS A0=n161 A1=n157 B0=n158 Y=n156
XU416 OAI21X2 $PINS A0=n205 A1=n207 B0=n206 Y=n204
XU417 NOR2X4 $PINS A=n160 B=n157 Y=n155
XU418 NOR2X4 $PINS A=B[34] B=A[34] Y=n396
XU419 AOI2BB1X4 $PINS A0N=n404 A1N=n91 B0=n86 Y=n397
XU422 INVX2 $PINS A=n97 Y=n96
XU423 AOI21X2 $PINS A0=n415 A1=n212 B0=n209 Y=n207
XU424 OAI21X1 $PINS A0=n213 A1=n215 B0=n214 Y=n212
XU425 XNOR2X1 $PINS A=n115 B=n13 Y=SUM[25]
XU426 NAND2X1 $PINS A=B[19] B=FE_OFN5976_N1510 Y=n147
XU427 NAND2X1 $PINS A=B[29] B=A[29] Y=n88
XU428 OAI21X4 $PINS A0=n1 A1=n48 B0=n49 Y=n47
XU429 AOI21X2 $PINS A0=n394 A1=n128 B0=n123 Y=n121
XU430 NOR2X2 $PINS A=B[21] B=A[21] Y=n135
XU431 AOI21X4 $PINS A0=n412 A1=n170 B0=n163 Y=n161
XU432 CLKINVX3 $PINS A=n165 Y=n163
XU433 OAI21X2 $PINS A0=n55 A1=n1 B0=n56 Y=n54
XU434 OAI21X4 $PINS A0=n386 A1=n1 B0=n42 Y=n40
XU435 NOR2X2 $PINS A=B[12] B=A[12] Y=n190
XU436 AOI21X4 $PINS A0=n188 A1=n196 B0=n189 Y=n187
XU437 OAI21X4 $PINS A0=n197 A1=n199 B0=n198 Y=n196
XU438 NOR2X4 $PINS A=B[17] B=A[17] Y=n157
XU439 NAND2X4 $PINS A=n50 B=n57 Y=n48
XU440 AOI21X4 $PINS A0=n174 A1=n155 B0=n156 Y=n154
XU441 OAI21X4 $PINS A0=n187 A1=n175 B0=n176 Y=n174
XU442 OAI21X2 $PINS A0=n135 A1=n139 B0=n136 Y=n134
XU443 OR2X2 $PINS A=B[19] B=FE_OFN5976_N1510 Y=n406
XU444 NAND2X2 $PINS A=B[33] B=A[33] Y=n53
XU445 AOI21X1 $PINS A0=n406 A1=n150 B0=n145 Y=n143
XU446 AND2X2 $PINS A=n46 B=n236 Y=n400
XU447 XNOR2X2 $PINS A=n78 B=n8 Y=SUM[30]
XU448 AOI21X4 $PINS A0=n141 A1=n133 B0=n134 Y=n132
XU449 INVX1 $PINS A=n147 Y=n145
XU450 INVX1 $PINS A=n231 Y=n2
XU451 NOR2X2 $PINS A=n135 B=n138 Y=n133
XU452 INVX1 $PINS A=n211 Y=n209
XU453 NOR2X1 $PINS A=B[11] B=A[11] Y=n193
XU454 OR2X2 $PINS A=FE_OFN6033_N1756 B=A[9] Y=n414
XU455 OR2X2 $PINS A=B[5] B=A[5] Y=n418
XU456 OR2X2 $PINS A=B[3] B=A[3] Y=n419
XU457 NOR2X2 $PINS A=B[20] B=A[20] Y=n138
XU458 NAND2X1 $PINS A=B[25] B=FE_OFN6113_N1516 Y=n114
XU459 OR2X4 $PINS A=B[27] B=A[27] Y=n407
XU460 OR2X2 $PINS A=FE_OFN6006_N1754 B=A[7] Y=n415
XU461 OAI21XL $PINS A0=n229 A1=n2 B0=n230 Y=n228
XU462 OAI21XL $PINS A0=n118 A1=n116 B0=n117 Y=n115
XU463 NAND2X2 $PINS A=n407 B=n409 Y=n98
XU464 INVX1 $PINS A=n125 Y=n123
XU465 NOR2X2 $PINS A=n116 B=n113 Y=n111
XU467 NAND2X4 $PINS A=B[20] B=A[20] Y=n139
XU468 NAND2X2 $PINS A=B[24] B=FE_OFN6136_N1515 Y=n117
XU469 OR2X4 $PINS A=B[29] B=A[29] Y=n411
XU470 NAND2XL $PINS A=n416 B=n185 Y=n25
XU471 NAND2BXL $PINS AN=n193 B=n194 Y=n27
XU472 NAND2BXL $PINS AN=n197 B=n198 Y=n28
XU473 NAND2XL $PINS A=n414 B=n203 Y=n29
XU474 NAND2BXL $PINS AN=n205 B=n206 Y=n30
XU475 NAND2BXL $PINS AN=n213 B=n214 Y=n32
XU476 NAND2XL $PINS A=n415 B=n211 Y=n31
XU477 NAND2XL $PINS A=B[6] B=A[6] Y=n214
XU478 NAND2XL $PINS A=n418 B=n219 Y=n33
XU479 NAND2XL $PINS A=B[4] B=A[4] Y=n222
XU480 NAND2XL $PINS A=B[2] B=A[2] Y=n230
XU481 OR2XL $PINS A=A[0] B=B[0] Y=n399
XU482 AND2X1 $PINS A=n409 B=n108 Y=n401
XU483 XNOR2XL $PINS A=n35 B=n228 Y=SUM[3]
XU484 XNOR2XL $PINS A=n36 B=n231 Y=SUM[2]
XU485 XOR2XL $PINS A=n34 B=n223 Y=SUM[4]
XU486 NAND2X4 $PINS A=n403 B=n143 Y=n141
XU487 INVXL $PINS A=n116 Y=n246
XU489 OR2X2 $PINS A=B[26] B=FE_OFN6161_N1517 Y=n409
XU490 OR2X2 $PINS A=B[22] B=FE_OFN5949_N1513 Y=n410
XU491 NAND2X1 $PINS A=B[23] B=FE_OFN5955_N1514 Y=n125
XU492 NAND2BX1 $PINS AN=n190 B=n191 Y=n26
XU493 NOR2BX1 $PINS AN=n65 B=n417 Y=n420
XU494 NAND2X1 $PINS A=B[16] B=FE_OFN6012_N1507 Y=n165
XU495 NAND2X1 $PINS A=B[11] B=A[11] Y=n194
XU496 NOR2X1 $PINS A=B[6] B=A[6] Y=n213
XU497 NAND2X1 $PINS A=FE_OFN6033_N1756 B=A[9] Y=n203
XU498 NAND2X1 $PINS A=FE_OFN6006_N1754 B=A[7] Y=n211
XU499 NAND2X1 $PINS A=B[13] B=A[13] Y=n185
XU500 NAND2BX1 $PINS AN=n221 B=n222 Y=n34
XU501 NOR2X1 $PINS A=B[4] B=A[4] Y=n221
XU502 NAND2X1 $PINS A=B[5] B=A[5] Y=n219
XU503 NAND2X1 $PINS A=n419 B=n227 Y=n35
XU504 NAND2X1 $PINS A=B[3] B=A[3] Y=n227
XU505 NAND2BX1 $PINS AN=n229 B=n230 Y=n36
XU506 NAND2BX4 $PINS AN=n38 B=n39 Y=n3
XU507 NOR2X1 $PINS A=B[2] B=A[2] Y=n229
XU508 XOR2X1 $PINS A=n148 B=n19 Y=SUM[19]
XU509 NAND2XL $PINS A=n406 B=n147 Y=n19
XU510 XNOR2X1 $PINS A=n153 B=n20 Y=SUM[18]
XU511 NAND2XL $PINS A=n405 B=n152 Y=n20
XU512 XNOR2X1 $PINS A=n166 B=n22 Y=SUM[16]
XU513 NAND2XL $PINS A=n412 B=n165 Y=n22
XU514 INVX1 $PINS A=n233 Y=n234
XU515 NAND2X1 $PINS A=A[0] B=B[0] Y=n233
XU516 NAND2XL $PINS A=n88 B=n411 Y=n9
XU517 XOR2X1 $PINS A=n96 B=n10 Y=SUM[28]
XU518 NAND2XL $PINS A=n407 B=n103 Y=n11
XU519 XOR2X1 $PINS A=n126 B=n15 Y=SUM[23]
XU520 NAND2XL $PINS A=n394 B=n125 Y=n15
XU521 XOR2X1 $PINS A=n118 B=n14 Y=SUM[24]
XU522 NAND2XL $PINS A=n246 B=n117 Y=n14
XU523 XNOR2X1 $PINS A=n131 B=n16 Y=SUM[22]
XU524 NAND2XL $PINS A=n410 B=FE_OFN5660_n130 Y=n16
XU525 XNOR2X1 $PINS A=n186 B=n25 Y=SUM[13]
XU526 XNOR2X1 $PINS A=n192 B=n26 Y=SUM[12]
XU527 XOR2X1 $PINS A=n173 B=n23 Y=SUM[15]
XU528 XOR2X1 $PINS A=n195 B=n27 Y=SUM[11]
XU529 XOR2X1 $PINS A=n181 B=n24 Y=SUM[14]
XU530 XNOR2X1 $PINS A=n137 B=n17 Y=SUM[21]
XU531 XOR2X1 $PINS A=n140 B=n18 Y=SUM[20]
XU532 XOR2X1 $PINS A=n199 B=n28 Y=SUM[10]
XU533 XOR2X1 $PINS A=n30 B=n207 Y=SUM[8]
XU534 XNOR2X1 $PINS A=n204 B=n29 Y=SUM[9]
XU535 XNOR2XL $PINS A=n31 B=n212 Y=SUM[7]
XU536 XNOR2XL $PINS A=n33 B=n220 Y=SUM[5]
XU537 XOR2XL $PINS A=n32 B=n215 Y=SUM[6]
XU538 NAND2XL $PINS A=n92 B=n91 Y=n10
XU539 INVX4 $PINS A=n67 Y=n65
XU340 NAND2BX2 $PINS AN=n167 B=n412 Y=n160
.ENDS

.SUBCKT CONV_DW01_add_39 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[35] SUM[34] SUM[33]
+ SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XFE_RC_631_0 CLKINVX3 $PINS A=n6 Y=FE_RN_343_0
XFE_RC_630_0 INVX8 $PINS A=FE_RN_344_0 Y=SUM[30]
XFE_RC_629_0 MXI2X4 $PINS S0=n75 B=FE_RN_343_0 A=n6 Y=FE_RN_344_0
XFE_RC_526_0 INVX1 $PINS A=n149 Y=FE_RN_289_0
XFE_RC_525_0 MX2X4 $PINS S0=n19 B=FE_RN_289_0 A=n149 Y=SUM[17]
XFE_OFC2174_N939 CLKBUFX8 $PINS A=A[33] Y=FE_OFN6122_N939
XFE_OFC2066_n51 INVX1 $PINS A=n51 Y=n49
XFE_OFC2032_n138 INVX1 $PINS A=n138 Y=n238
XFE_OFC2018_N919 CLKBUFX8 $PINS A=A[13] Y=FE_OFN6047_N919
XFE_OFC1027_n162 INVX4 $PINS A=n162 Y=FE_DBTN151_n162
XFE_OFC884_n141 CLKINVX3 $PINS A=n141 Y=n140
XFE_OFC831_n101 INVX4 $PINS A=n101 Y=n100
XFE_OFC169_n416 INVX1 $PINS A=n416 Y=n197
XU36 XOR2X4 $PINS A=n66 B=n5 Y=SUM[31]
XU44 NOR2X4 $PINS A=A[31] B=B[31] Y=n62
XU52 NOR2X2 $PINS A=n73 B=n78 Y=n67
XU53 OAI21X2 $PINS A0=n73 A1=n79 B0=n74 Y=n68
XU56 NOR2X4 $PINS A=A[30] B=B[30] Y=n73
XU66 XNOR2X4 $PINS A=n86 B=n8 Y=SUM[28]
XU69 NOR2X2 $PINS A=n87 B=n84 Y=n82
XU75 XNOR2X4 $PINS A=n93 B=n9 Y=SUM[27]
XU78 AOI21X4 $PINS A0=n89 A1=n97 B0=n90 Y=n88
XU83 NOR2X2 $PINS A=A[27] B=B[27] Y=n91
XU116 AOI21X4 $PINS A0=n123 A1=n115 B0=n116 Y=n114
XU121 NOR2X4 $PINS A=A[23] B=B[23] Y=n117
XU127 NOR2X2 $PINS A=A[22] B=B[22] Y=n120
XU131 OAI21X4 $PINS A0=n141 A1=n124 B0=n125 Y=n123
XU158 AOI21X4 $PINS A0=n150 A1=n142 B0=n143 Y=n141
XU163 NOR2X4 $PINS A=B[18] B=A[18] Y=n144
XU169 NOR2X2 $PINS A=B[17] B=A[17] Y=n147
XU285 ADDFX2 $PINS A=n219 B=A[1] CI=B[1] S=SUM[1] CO=n218
XU295 NAND2X2 $PINS A=n131 B=n401 Y=n124
XU296 NAND2BX1 $PINS AN=n181 B=n182 Y=n26
XU298 NAND2X2 $PINS A=B[30] B=A[30] Y=n74
XU299 NAND2X1 $PINS A=B[11] B=A[11] Y=n179
XU300 XOR2X2 $PINS A=n174 B=n395 Y=SUM[12]
XU302 AND2X2 $PINS A=n60 B=n80 Y=n371
XU303 NOR2X2 $PINS A=n371 B=n61 Y=n59
XU304 OAI2BB1X1 $PINS A0N=n68 A1N=n381 B0=n65 Y=n61
XU305 NAND2X2 $PINS A=n80 B=n76 Y=n372
XU307 AND2X4 $PINS A=n372 B=n79 Y=n75
XU308 CLKINVX3 $PINS A=n78 Y=n76
XU310 NAND2XL $PINS A=n140 B=n17 Y=n376
XU311 NAND2X1 $PINS A=n141 B=n375 Y=n377
XU312 NAND2X4 $PINS A=n376 B=n377 Y=SUM[19]
XU314 INVXL $PINS A=n17 Y=n375
XU315 NAND2X1 $PINS A=n238 B=n139 Y=n17
XU316 NAND2X1 $PINS A=n123 B=n379 Y=n380
XU317 NAND2X1 $PINS A=n380 B=n121 Y=n119
XU319 INVX1 $PINS A=n120 Y=n379
XU320 OAI21X1 $PINS A0=FE_DBTN151_n162 A1=n159 B0=n160 Y=n158
XU323 NAND2X1 $PINS A=B[6] B=A[6] Y=n198
XU324 INVX1 $PINS A=n107 Y=n105
XU325 NAND2X1 $PINS A=B[9] B=A[9] Y=n187
XU326 XNOR2X2 $PINS A=n158 B=n21 Y=SUM[15]
XU327 NAND2X2 $PINS A=A[24] B=B[24] Y=n112
XU328 XOR2X1 $PINS A=FE_DBTN151_n162 B=n22 Y=SUM[14]
XU329 AOI21X2 $PINS A0=n140 A1=n238 B0=n137 Y=n135
XU331 NAND2BX1 $PINS AN=n120 B=n121 Y=n14
XU332 INVX1 $PINS A=n62 Y=n381
XU333 NAND2BX1 $PINS AN=n144 B=n145 Y=n18
XU334 NAND2BXL $PINS AN=n388 B=n134 Y=n16
XU335 AOI21X1 $PINS A0=n204 A1=n411 B0=n201 Y=n199
XU336 NAND2BX1 $PINS AN=n147 B=n148 Y=n19
XU337 AOI21X2 $PINS A0=n196 A1=n410 B0=n193 Y=n191
XU338 OR2X2 $PINS A=n57 B=n382 Y=n4
XU339 INVX1 $PINS A=n58 Y=n382
XU340 XNOR2X1 $PINS A=B[14] B=A[14] Y=n22
XU341 NAND2X1 $PINS A=n398 B=n107 Y=n11
XU342 OAI21XL $PINS A0=n205 A1=n207 B0=n206 Y=n204
XU343 NAND2X1 $PINS A=B[14] B=A[14] Y=n160
XU344 AOI21X2 $PINS A0=n188 A1=n407 B0=n185 Y=n183
XU345 INVX1 $PINS A=n187 Y=n185
XU346 OR2X2 $PINS A=n62 B=n383 Y=n5
XU347 INVX1 $PINS A=n65 Y=n383
XU348 AOI21X4 $PINS A0=n52 A1=n409 B0=n49 Y=n47
XU350 NAND2BX1 $PINS AN=n156 B=n157 Y=n21
XU351 NAND2X1 $PINS A=n406 B=n179 Y=n25
XU352 NAND2BX1 $PINS AN=n205 B=n206 Y=n32
XU353 NAND2XL $PINS A=n407 B=n187 Y=n27
XU354 AOI21X2 $PINS A0=n80 A1=n67 B0=n68 Y=n66
XU355 NOR2BX1 $PINS AN=n221 B=n220 Y=SUM[0]
XU356 NAND2BX1 $PINS AN=n151 B=n152 Y=n20
XU357 NAND2BX1 $PINS AN=n197 B=n198 Y=n30
XU358 NAND2BX1 $PINS AN=n189 B=n190 Y=n28
XU359 XOR2X4 $PINS A=n38 B=n1 Y=SUM[35]
XU361 OAI21X2 $PINS A0=n100 A1=n87 B0=n88 Y=n86
XU362 INVX1 $PINS A=n92 Y=n90
XU363 INVX4 $PINS A=n91 Y=n89
XU364 OAI2BB1X1 $PINS A0N=n408 A1N=n49 B0=n46 Y=n404
XU365 XOR2X2 $PINS A=n169 B=n23 Y=SUM[13]
XU366 XOR2X2 $PINS A=n47 B=n2 Y=SUM[34]
XU367 AND2X2 $PINS A=n405 B=n173 Y=n395
XU368 AOI21X2 $PINS A0=n140 A1=n131 B0=n132 Y=n130
XU369 AOI21X2 $PINS A0=n398 A1=n110 B0=n105 Y=n103
XU371 INVX1 $PINS A=n168 Y=n166
XU372 NAND2X1 $PINS A=A[25] B=B[25] Y=n107
XU373 INVX4 $PINS A=n114 Y=n113
XU374 XOR2X4 $PINS A=n113 B=n397 Y=SUM[24]
XU375 NAND2X2 $PINS A=A[22] B=B[22] Y=n121
XU376 NAND2X1 $PINS A=A[32] B=B[32] Y=n58
XU377 NOR2X4 $PINS A=A[32] B=B[32] Y=n57
XU378 OAI21X1 $PINS A0=n57 A1=n65 B0=n58 Y=n56
XU380 OAI21X1 $PINS A0=n160 A1=n156 B0=n157 Y=n155
XU381 NOR2X2 $PINS A=B[16] B=A[16] Y=n151
XU382 NAND2X1 $PINS A=B[16] B=A[16] Y=n152
XU383 INVX1 $PINS A=n203 Y=n201
XU384 NAND2X2 $PINS A=A[27] B=B[27] Y=n92
XU385 INVX1 $PINS A=n173 Y=n171
XU386 OAI2BB1X1 $PINS A0N=n414 A1N=n218 B0=n217 Y=n415
XU387 NOR2X1 $PINS A=B[8] B=A[8] Y=n189
XU388 NOR2X1 $PINS A=B[10] B=A[10] Y=n181
XU389 NAND2X1 $PINS A=B[10] B=A[10] Y=n182
XU391 NAND2X2 $PINS A=n413 B=n37 Y=n1
XU392 OR2X2 $PINS A=n156 B=n159 Y=n384
XU393 INVX2 $PINS A=n150 Y=n149
XU394 XOR2X2 $PINS A=n26 B=n183 Y=SUM[10]
XU395 AOI21X2 $PINS A0=n403 A1=n52 B0=n404 Y=n38
XU396 INVX1 $PINS A=n195 Y=n193
XU397 NAND2XL $PINS A=B[7] B=A[7] Y=n195
XU398 NOR2X1 $PINS A=n120 B=n117 Y=n115
XU399 OR2X2 $PINS A=A[34] B=B[34] Y=n408
XU400 AND2X2 $PINS A=n408 B=n409 Y=n403
XU401 XNOR2X2 $PINS A=n146 B=n18 Y=SUM[18]
XU402 OAI21X2 $PINS A0=n121 A1=n117 B0=n118 Y=n116
XU403 NAND2X2 $PINS A=B[29] B=A[29] Y=n79
XU404 NAND2X1 $PINS A=A[21] B=B[21] Y=n129
XU405 NAND2X2 $PINS A=A[28] B=B[28] Y=n85
XU407 INVX1 $PINS A=n211 Y=n209
XU408 NOR2X1 $PINS A=B[4] B=A[4] Y=n205
XU409 NAND2X1 $PINS A=B[4] B=A[4] Y=n206
XU410 INVX1 $PINS A=n221 Y=n219
XU411 NAND2X2 $PINS A=B[20] B=A[20] Y=n134
XU412 INVX1 $PINS A=n112 Y=n110
XU413 INVX1 $PINS A=n179 Y=n177
XU414 AND2X2 $PINS A=n409 B=n51 Y=n402
XU415 NAND2X1 $PINS A=A[34] B=B[34] Y=n46
XU416 NAND2BX1 $PINS AN=n73 B=n74 Y=n6
XU417 INVX4 $PINS A=n95 Y=n97
XU418 OAI21X1 $PINS A0=n197 A1=n199 B0=n198 Y=n196
XU419 OAI21X2 $PINS A0=n144 A1=n148 B0=n145 Y=n143
XU420 XNOR2X2 $PINS A=n188 B=n27 Y=SUM[9]
XU421 NAND2XL $PINS A=n410 B=n195 Y=n29
XU422 NAND2X1 $PINS A=B[8] B=A[8] Y=n190
XU423 XOR2X2 $PINS A=n122 B=n14 Y=SUM[22]
XU424 AOI21X2 $PINS A0=n55 A1=n68 B0=n56 Y=n54
XU425 NAND2X1 $PINS A=n55 B=n67 Y=n53
XU426 OAI21X4 $PINS A0=n191 A1=n189 B0=n190 Y=n188
XU427 NOR2BX1 $PINS AN=n67 B=n62 Y=n60
XU428 NOR2X1 $PINS A=B[14] B=A[14] Y=n159
XU429 AOI21X4 $PINS A0=n132 A1=n401 B0=n127 Y=n125
XU430 NOR2X4 $PINS A=B[20] B=A[20] Y=n388
XU431 NAND2X2 $PINS A=B[18] B=A[18] Y=n145
XU432 AND2X2 $PINS A=n76 B=n79 Y=n396
XU434 AND2X2 $PINS A=n390 B=n118 Y=n394
XU435 AND2X2 $PINS A=n400 B=n112 Y=n397
XU436 NAND2X1 $PINS A=B[15] B=A[15] Y=n157
XU437 XOR2X2 $PINS A=n119 B=n394 Y=SUM[23]
XU438 NAND2X1 $PINS A=n399 B=n405 Y=n163
XU439 AOI21X4 $PINS A0=n113 A1=n400 B0=n110 Y=n108
XU440 OR2XL $PINS A=A[23] B=B[23] Y=n390
XU441 INVX1 $PINS A=n129 Y=n127
XU442 XOR2X2 $PINS A=n59 B=n4 Y=SUM[32]
XU443 OAI21X4 $PINS A0=n88 A1=n84 B0=n85 Y=n83
XU444 OR2X4 $PINS A=A[25] B=B[25] Y=n398
XU445 AOI21X2 $PINS A0=n399 A1=n171 B0=n166 Y=n164
XU446 NOR2X4 $PINS A=A[29] B=B[29] Y=n78
XU447 OAI21X4 $PINS A0=n100 A1=n94 B0=n95 Y=n93
XU448 NOR2X2 $PINS A=n144 B=n147 Y=n142
XU449 XOR2X4 $PINS A=n108 B=n11 Y=SUM[25]
XU450 NOR2X4 $PINS A=n388 B=n138 Y=n131
XU451 NOR2X2 $PINS A=n384 B=FE_DBTN151_n162 Y=n393
XU452 OAI21X4 $PINS A0=n183 A1=n181 B0=n182 Y=n180
XU453 OAI21X1 $PINS A0=n149 A1=n147 B0=n148 Y=n146
XU454 NAND2X1 $PINS A=n408 B=n46 Y=n2
XU455 OR2X2 $PINS A=B[9] B=A[9] Y=n407
XU456 NOR2X4 $PINS A=n393 B=n155 Y=n153
XU457 NAND2X4 $PINS A=A[26] B=B[26] Y=n95
XU458 OAI21X4 $PINS A0=n163 A1=n175 B0=n164 Y=n162
XU459 AOI21X4 $PINS A0=n180 A1=n406 B0=n177 Y=n175
XU460 OAI21X4 $PINS A0=n53 A1=n81 B0=n54 Y=n52
XU461 AOI21X4 $PINS A0=n101 A1=n82 B0=n83 Y=n81
XU462 OAI21X4 $PINS A0=n114 A1=n102 B0=n103 Y=n101
XU463 XOR2X4 $PINS A=n80 B=n396 Y=SUM[29]
XU464 INVX8 $PINS A=n81 Y=n80
XU465 XOR2X4 $PINS A=n130 B=n15 Y=SUM[21]
XU466 CLKINVX3 $PINS A=n94 Y=n96
XU467 NOR2X4 $PINS A=A[26] B=B[26] Y=n94
XU468 NOR2X4 $PINS A=B[15] B=A[15] Y=n156
XU469 NAND2X2 $PINS A=B[17] B=A[17] Y=n148
XU470 NAND2X2 $PINS A=A[31] B=B[31] Y=n65
XU471 XOR2X2 $PINS A=n52 B=n402 Y=SUM[33]
XU472 OAI21X4 $PINS A0=n388 A1=n139 B0=n134 Y=n132
XU473 NOR2X2 $PINS A=A[19] B=B[19] Y=n138
XU475 NAND2X2 $PINS A=B[19] B=A[19] Y=n139
XU476 OR2X2 $PINS A=B[13] B=FE_OFN6047_N919 Y=n399
XU477 OR2X1 $PINS A=A[7] B=B[7] Y=n410
XU478 OAI21X4 $PINS A0=n153 A1=n151 B0=n152 Y=n150
XU479 XOR2X1 $PINS A=n32 B=n207 Y=SUM[4]
XU480 OR2X2 $PINS A=B[11] B=A[11] Y=n406
XU481 OR2X2 $PINS A=B[5] B=A[5] Y=n411
XU482 OR2X2 $PINS A=B[3] B=A[3] Y=n412
XU483 INVX1 $PINS A=n123 Y=n122
XU484 NOR2X4 $PINS A=A[28] B=B[28] Y=n84
XU485 INVX2 $PINS A=n175 Y=n174
XU487 NOR2X2 $PINS A=n62 B=n57 Y=n55
XU488 OR2X4 $PINS A=FE_OFN6122_N939 B=B[33] Y=n409
XU489 NAND2XL $PINS A=n401 B=n129 Y=n15
XU490 XNOR2X2 $PINS A=n25 B=n180 Y=SUM[11]
XU491 XOR2X2 $PINS A=n28 B=n191 Y=SUM[8]
XU492 NAND2BX1 $PINS AN=n84 B=n85 Y=n8
XU493 NAND2X2 $PINS A=n398 B=n400 Y=n102
XU495 NAND2X2 $PINS A=n96 B=n89 Y=n87
XU496 NAND2X1 $PINS A=B[13] B=FE_OFN6047_N919 Y=n168
XU497 NAND2X1 $PINS A=B[12] B=A[12] Y=n173
XU498 XOR2X2 $PINS A=n30 B=n199 Y=SUM[6]
XU499 NAND2XL $PINS A=n411 B=n203 Y=n31
XU500 NAND2XL $PINS A=B[2] B=A[2] Y=n217
XU501 NAND2XL $PINS A=n412 B=n211 Y=n33
XU502 NAND2XL $PINS A=B[0] B=A[0] Y=n221
XU503 NOR2XL $PINS A=B[0] B=A[0] Y=n220
XU504 INVX1 $PINS A=n139 Y=n137
XU505 XOR2X4 $PINS A=n135 B=n16 Y=SUM[20]
XU506 NAND2XL $PINS A=n89 B=n92 Y=n9
XU507 XOR2X1 $PINS A=n153 B=n20 Y=SUM[16]
XU508 NAND2X1 $PINS A=n399 B=n168 Y=n23
XU509 AOI21X1 $PINS A0=n174 A1=n405 B0=n171 Y=n169
XU510 OR2X2 $PINS A=A[24] B=B[24] Y=n400
XU511 OR2X4 $PINS A=A[21] B=B[21] Y=n401
XU512 NAND2X1 $PINS A=A[23] B=B[23] Y=n118
XU513 OR2X2 $PINS A=B[12] B=A[12] Y=n405
XU514 XNOR2X2 $PINS A=n29 B=n196 Y=SUM[7]
XU515 NAND2X1 $PINS A=FE_OFN6122_N939 B=B[33] Y=n51
XU516 NAND2X1 $PINS A=B[5] B=A[5] Y=n203
XU517 XNOR2X1 $PINS A=n31 B=n204 Y=SUM[5]
XU518 NAND2X1 $PINS A=A[35] B=B[35] Y=n37
XU519 NAND2X1 $PINS A=B[3] B=A[3] Y=n211
XU520 OR2X2 $PINS A=A[35] B=B[35] Y=n413
XU521 AOI21X1 $PINS A0=n412 A1=n415 B0=n209 Y=n207
XU522 XNOR2X1 $PINS A=n33 B=n415 Y=SUM[3]
XU523 OR2X2 $PINS A=B[2] B=A[2] Y=n414
XU524 XNOR2X1 $PINS A=n34 B=n218 Y=SUM[2]
XU525 NAND2XL $PINS A=n414 B=n217 Y=n34
XU322 OR2X2 $PINS A=B[6] B=A[6] Y=n416
XU494 XNOR2X1 $PINS A=n100 B=n417 Y=SUM[26]
XU526 AND2X2 $PINS A=n96 B=n95 Y=n417
.ENDS

.SUBCKT CONV_DW01_sub_14 A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23]
+ B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10]
+ B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] CI DIFF[35] DIFF[34]
+ DIFF[33] DIFF[32] DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO p1
XFE_RC_634_0 INVX1 $PINS A=n115 Y=FE_RN_345_0
XFE_RC_633_0 MX2X4 $PINS S0=n12 B=n115 A=FE_RN_345_0 Y=DIFF[24]
XFE_OFC2222_n80 INVX1 $PINS A=n80 Y=n78
XFE_OFC2204_n107 INVX1 $PINS A=n107 Y=n232
XFE_OFC2146_n55 INVX1 $PINS A=n55 Y=n53
XFE_OFC639_N885 INVX1 $PINS A=B[14] Y=n276
XFE_OFC589_n405 INVX1 $PINS A=n405 Y=n212
XFE_OFC257_n130 INVX1 $PINS A=n130 Y=n128
XFE_OFC232_n217 INVX1 $PINS A=n217 Y=n216
XFE_DBTC150_n97 INVX1 $PINS A=n97 Y=FE_DBTN150_n97
XU35 NOR2X2 $PINS A=A[32] B=n258 Y=n58
XU37 XOR2X4 $PINS A=n67 B=n5 Y=DIFF[31]
XU45 NOR2X2 $PINS A=A[31] B=n259 Y=n63
XU54 OAI21X2 $PINS A0=n74 A1=n80 B0=n75 Y=n69
XU57 NOR2X2 $PINS A=A[30] B=n260 Y=n74
XU85 NOR2X2 $PINS A=A[27] B=n263 Y=n91
XU94 OAI21X2 $PINS A0=n102 A1=n108 B0=n103 Y=n97
XU97 NOR2X2 $PINS A=A[26] B=n264 Y=n102
XU109 AOI21X4 $PINS A0=n119 A1=n111 B0=n112 Y=n110
XU111 OAI21X1 $PINS A0=n113 A1=n117 B0=n114 Y=n112
XU114 NOR2X2 $PINS A=A[24] B=n266 Y=n113
XU116 XOR2X4 $PINS A=n118 B=n13 Y=DIFF[23]
XU120 NOR2X2 $PINS A=A[23] B=n267 Y=n116
XU124 OAI21X4 $PINS A0=n120 A1=n132 B0=n121 Y=n119
XU143 AOI21X4 $PINS A0=n141 A1=n133 B0=n134 Y=n132
XU144 NOR2X2 $PINS A=n135 B=n138 Y=n133
XU145 OAI21X2 $PINS A0=n135 A1=n139 B0=n136 Y=n134
XU148 NOR2X2 $PINS A=A[20] B=n270 Y=n135
XU158 OAI21X4 $PINS A0=n154 A1=n142 B0=n143 Y=n141
XU177 AOI21X4 $PINS A0=n159 A1=n433 B0=n156 Y=n154
XU327 NAND2BXL $PINS AN=n214 B=n215 Y=n33
XU328 OAI21XL $PINS A0=n214 A1=n216 B0=n215 Y=n405
XU329 NAND2X2 $PINS A=A[23] B=n267 Y=n117
XU332 NOR2X2 $PINS A=A[9] B=n281 Y=n190
XU333 NAND2XL $PINS A=n433 B=n158 Y=n20
XU334 INVX1 $PINS A=n158 Y=n156
XU335 OR2X2 $PINS A=n55 B=n47 Y=n402
XU336 NAND2X1 $PINS A=n402 B=n50 Y=n46
XU337 NOR2X1 $PINS A=A[33] B=n257 Y=n47
XU338 NAND2X1 $PINS A=A[33] B=n257 Y=n50
XU339 NAND2X1 $PINS A=n109 B=n96 Y=n403
XU341 AND2X4 $PINS A=n403 B=FE_DBTN150_n97 Y=n95
XU342 NAND2X1 $PINS A=n413 B=n136 Y=n16
XU343 NAND2X1 $PINS A=A[21] B=n269 Y=n130
XU344 XOR2X1 $PINS A=n51 B=n3 Y=DIFF[33]
XU346 NOR2X1 $PINS A=B[11] B=A[11] Y=n182
XU347 NAND2X1 $PINS A=A[11] B=B[11] Y=n183
XU348 INVX1 $PINS A=B[20] Y=n270
XU349 NOR2X1 $PINS A=n113 B=n116 Y=n111
XU350 INVX1 $PINS A=B[32] Y=n258
XU351 INVX1 $PINS A=B[17] Y=n273
XU352 NOR2X1 $PINS A=A[6] B=n284 Y=n202
XU353 INVX1 $PINS A=B[8] Y=n282
XU354 NAND2X1 $PINS A=A[17] B=n273 Y=n152
XU355 INVX1 $PINS A=B[21] Y=n269
XU356 INVX1 $PINS A=B[25] Y=n265
XU357 NAND2X1 $PINS A=A[27] B=n263 Y=n94
XU359 NAND2X1 $PINS A=A[7] B=n283 Y=n200
XU360 NAND2X1 $PINS A=A[8] B=n282 Y=n195
XU361 OAI21XL $PINS A0=n175 A1=n179 B0=n176 Y=n174
XU362 OR2X2 $PINS A=A[21] B=n269 Y=n430
XU363 XOR2X1 $PINS A=n192 B=n27 Y=DIFF[9]
XU364 XNOR2X1 $PINS A=n189 B=n26 Y=DIFF[10]
XU365 NAND2X1 $PINS A=n227 B=n75 Y=n425
XU366 XOR2X2 $PINS A=n35 B=A[35] Y=DIFF[35]
XU367 AOI21X1 $PINS A0=n97 A1=n84 B0=n85 Y=n83
XU368 XNOR2X4 $PINS A=n1 B=n419 Y=DIFF[29]
XU369 AOI21X1 $PINS A0=n436 A1=n209 B0=n206 Y=n204
XU370 AOI21X4 $PINS A0=n77 A1=n1 B0=n78 Y=n76
XU371 INVX1 $PINS A=n79 Y=n77
XU372 AOI21X2 $PINS A0=n131 A1=n430 B0=n128 Y=n126
XU373 INVX2 $PINS A=n132 Y=n131
XU375 NOR2BX1 $PINS AN=n87 B=n86 Y=n426
XU376 NAND2BX1 $PINS AN=n63 B=n66 Y=n5
XU377 OAI21XL $PINS A0=n202 A1=n204 B0=n203 Y=n201
XU378 NOR2X1 $PINS A=n175 B=n178 Y=n173
XU379 NAND2XL $PINS A=n411 B=n125 Y=n421
XU380 OAI2BB1X1 $PINS A0N=n69 A1N=n406 B0=n66 Y=n62
XU381 INVX1 $PINS A=n63 Y=n406
XU382 NAND2BX1 $PINS AN=n202 B=n203 Y=n30
XU383 NAND2BX1 $PINS AN=n175 B=n176 Y=n23
XU384 NAND2BX1 $PINS AN=n194 B=n195 Y=n28
XU385 NAND2BX1 $PINS AN=n190 B=n191 Y=n27
XU386 NAND2BX1 $PINS AN=n47 B=n50 Y=n3
XU387 NAND2BX1 $PINS AN=n102 B=n103 Y=n424
XU388 OAI2BB1X4 $PINS A0N=n410 A1N=n416 B0=n161 Y=n159
XU389 NAND2BX1 $PINS AN=n210 B=n211 Y=n32
XU390 NAND2BXL $PINS AN=n187 B=n188 Y=n26
XU391 NAND2BXL $PINS AN=n42 B=n43 Y=n2
XU392 AOI21X1 $PINS A0=n201 A1=n435 B0=n198 Y=n196
XU393 OAI221XL $PINS A0=n55 A1=n434 B0=n42 B1=n50 C0=n43 Y=n37
XU395 NAND2X1 $PINS A=A[10] B=n280 Y=n188
XU396 NAND2BX1 $PINS AN=n58 B=n59 Y=n4
XU397 XOR2X1 $PINS A=n30 B=n204 Y=DIFF[6]
XU398 NAND2BX1 $PINS AN=n138 B=n139 Y=n17
XU399 NAND2X1 $PINS A=n232 B=n108 Y=n423
XU400 NOR2BX1 $PINS AN=n68 B=n63 Y=n61
XU401 AOI21X2 $PINS A0=n153 A1=n431 B0=n150 Y=n148
XU402 INVX1 $PINS A=n152 Y=n150
XU403 NAND2BX1 $PINS AN=n218 B=n219 Y=n34
XU404 XNOR3X2 $PINS A=n184 B=A[11] C=B[11] Y=DIFF[11]
XU405 NAND2BX1 $PINS AN=n178 B=n179 Y=n24
XU406 NAND2X1 $PINS A=n411 B=n430 Y=n120
XU407 INVX2 $PINS A=n154 Y=n153
XU408 NAND2BX1 $PINS AN=n116 B=n117 Y=n13
XU409 OAI21XL $PINS A0=n192 A1=n190 B0=n191 Y=n189
XU410 INVX1 $PINS A=n193 Y=n192
XU411 NAND2X2 $PINS A=A[9] B=n281 Y=n191
XU412 OAI21XL $PINS A0=n210 A1=n212 B0=n211 Y=n209
XU413 AND2X4 $PINS A=n185 B=n193 Y=n417
XU414 INVX1 $PINS A=n125 Y=n123
XU415 AOI21X2 $PINS A0=n181 A1=n173 B0=n174 Y=n172
XU416 NOR2X1 $PINS A=A[8] B=n282 Y=n194
XU417 INVX1 $PINS A=n147 Y=n145
XU418 INVX1 $PINS A=n119 Y=n118
XU419 NOR2X2 $PINS A=A[29] B=n261 Y=n79
XU420 NAND2XL $PINS A=n429 B=n165 Y=n21
XU421 INVX1 $PINS A=n165 Y=n163
XU423 NAND2X1 $PINS A=A[12] B=n278 Y=n179
XU424 XOR2X4 $PINS A=n126 B=n421 Y=DIFF[22]
XU425 XOR2X4 $PINS A=n60 B=n4 Y=DIFF[32]
XU426 AOI21X2 $PINS A0=n1 A1=n61 B0=n62 Y=n60
XU427 NAND2X1 $PINS A=A[30] B=n260 Y=n75
XU428 NAND2XL $PINS A=n431 B=n152 Y=n19
XU429 NAND2X1 $PINS A=n230 B=n94 Y=n422
XU430 INVX1 $PINS A=B[18] Y=n272
XU432 INVX1 $PINS A=B[5] Y=n285
XU434 INVX1 $PINS A=B[13] Y=n277
XU435 INVX1 $PINS A=B[31] Y=n259
XU436 INVX1 $PINS A=B[30] Y=n260
XU437 NAND2X1 $PINS A=A[15] B=n275 Y=n165
XU438 NAND2BX1 $PINS AN=B[1] B=B[0] Y=n220
XU439 NAND2X1 $PINS A=n68 B=n56 Y=n54
XU440 OAI21XL $PINS A0=FE_DBTN150_n97 A1=n91 B0=n94 Y=n90
XU441 INVX1 $PINS A=n91 Y=n230
XU442 NOR2X1 $PINS A=n54 B=n434 Y=n36
XU443 NAND2X1 $PINS A=n414 B=n114 Y=n12
XU444 AOI21X1 $PINS A0=n36 A1=n1 B0=n37 Y=n35
XU445 INVX1 $PINS A=B[19] Y=n271
XU446 XNOR2X1 $PINS A=n29 B=n201 Y=DIFF[7]
XU447 NAND2X1 $PINS A=A[3] B=n287 Y=n215
XU449 XOR2X4 $PINS A=n44 B=n2 Y=DIFF[34]
XU450 CLKINVX3 $PINS A=n181 Y=n180
XU451 INVX1 $PINS A=B[22] Y=n268
XU452 CLKINVX3 $PINS A=n172 Y=n416
XU453 OR2X2 $PINS A=A[20] B=n270 Y=n413
XU454 NAND2X1 $PINS A=n77 B=n80 Y=n419
XU455 NAND2X1 $PINS A=n109 B=n232 Y=n409
XU456 AND2X4 $PINS A=n409 B=n108 Y=n104
XU457 NOR2X1 $PINS A=A[34] B=n256 Y=n42
XU458 NAND2X1 $PINS A=A[34] B=n256 Y=n43
XU459 XOR2X4 $PINS A=n131 B=n420 Y=DIFF[21]
XU460 NAND2X2 $PINS A=n271 B=A[19] Y=n139
XU462 NOR2X2 $PINS A=A[19] B=n271 Y=n138
XU463 XNOR2X4 $PINS A=n88 B=n426 Y=DIFF[28]
XU464 INVX1 $PINS A=B[28] Y=n262
XU467 INVX1 $PINS A=B[16] Y=n274
XU468 INVX1 $PINS A=B[15] Y=n275
XU469 INVX1 $PINS A=B[6] Y=n284
XU470 INVX1 $PINS A=B[27] Y=n263
XU471 INVX1 $PINS A=B[12] Y=n278
XU472 INVX1 $PINS A=B[3] Y=n287
XU473 INVX1 $PINS A=B[4] Y=n286
XU474 INVX1 $PINS A=B[29] Y=n261
XU475 INVX1 $PINS A=B[33] Y=n257
XU476 NAND2X1 $PINS A=A[16] B=n274 Y=n158
XU477 NAND2X1 $PINS A=A[6] B=n284 Y=n203
XU478 NAND2X1 $PINS A=n428 B=n431 Y=n142
XU479 NOR2X2 $PINS A=A[25] B=n265 Y=n107
XU480 INVX1 $PINS A=B[26] Y=n264
XU482 NAND2X2 $PINS A=A[25] B=n265 Y=n108
XU483 INVX1 $PINS A=B[24] Y=n266
XU484 INVX1 $PINS A=n116 Y=n412
XU485 XNOR2X2 $PINS A=n416 B=n22 Y=DIFF[14]
XU486 INVX1 $PINS A=B[23] Y=n267
XU487 AOI21X2 $PINS A0=n89 A1=n109 B0=n90 Y=n88
XU488 INVX1 $PINS A=n74 Y=n227
XU489 AND2X2 $PINS A=n429 B=n432 Y=n410
XU490 NAND2X2 $PINS A=A[29] B=n261 Y=n80
XU491 AOI21X2 $PINS A0=n1 A1=n68 B0=n69 Y=n67
XU492 OAI21X4 $PINS A0=n140 A1=n138 B0=n139 Y=n137
XU493 OR2X4 $PINS A=A[22] B=n268 Y=n411
XU494 XOR2X2 $PINS A=n180 B=n24 Y=DIFF[12]
XU495 OAI2BB1X1 $PINS A0N=n412 A1N=n119 B0=n117 Y=n115
XU497 OAI21X1 $PINS A0=n58 A1=n66 B0=n59 Y=n57
XU498 NOR2X1 $PINS A=n63 B=n58 Y=n56
XU499 NAND2X1 $PINS A=A[28] B=n262 Y=n87
XU500 NOR2X2 $PINS A=A[10] B=n280 Y=n187
XU501 OR2X2 $PINS A=A[7] B=n283 Y=n435
XU502 AND2X2 $PINS A=n430 B=n130 Y=n420
XU503 NOR2X1 $PINS A=n187 B=n190 Y=n185
XU504 OAI21X2 $PINS A0=n187 A1=n191 B0=n188 Y=n186
XU505 OR2XL $PINS A=A[24] B=n266 Y=n414
XU506 NOR2BX1 $PINS AN=n96 B=n91 Y=n89
XU507 OR2X2 $PINS A=A[17] B=n273 Y=n431
XU508 OR2X2 $PINS A=A[15] B=n275 Y=n429
XU509 XOR2X4 $PINS A=n148 B=n18 Y=DIFF[18]
XU510 AOI21X2 $PINS A0=n411 A1=n128 B0=n123 Y=n121
XU512 OAI21XL $PINS A0=n180 A1=n178 B0=n179 Y=n177
XU513 NOR2X1 $PINS A=A[12] B=n278 Y=n178
XU514 XNOR2X2 $PINS A=n153 B=n19 Y=DIFF[17]
XU515 XNOR2X1 $PINS A=n177 B=n23 Y=DIFF[13]
XU516 NAND2X1 $PINS A=A[13] B=n277 Y=n176
XU517 AOI21X2 $PINS A0=n416 A1=n432 B0=n168 Y=n166
XU518 NOR2X2 $PINS A=A[13] B=n277 Y=n175
XU519 OR2X2 $PINS A=n47 B=n42 Y=n434
XU520 OAI21X1 $PINS A0=n196 A1=n194 B0=n195 Y=n193
XU521 XOR2X1 $PINS A=n28 B=n196 Y=DIFF[8]
XU522 NOR2X1 $PINS A=n54 B=n47 Y=n45
XU523 XOR2X2 $PINS A=n166 B=n21 Y=DIFF[15]
XU524 OAI21XL $PINS A0=n86 A1=n94 B0=n87 Y=n85
XU525 AOI21X2 $PINS A0=n428 A1=n150 B0=n145 Y=n143
XU526 AOI21X2 $PINS A0=n56 A1=n69 B0=n57 Y=n55
XU527 XNOR2X4 $PINS A=n109 B=n423 Y=DIFF[25]
XU528 XNOR2X4 $PINS A=n137 B=n16 Y=DIFF[20]
XU529 OAI21X4 $PINS A0=n184 A1=n182 B0=n183 Y=n181
XU530 NOR2X4 $PINS A=n417 B=n186 Y=n184
XU531 AOI21X1 $PINS A0=n1 A1=n52 B0=n53 Y=n51
XU532 AOI21X2 $PINS A0=n45 A1=n1 B0=n46 Y=n44
XU533 NAND2X1 $PINS A=A[31] B=n259 Y=n66
XU534 NOR2X1 $PINS A=n86 B=n91 Y=n84
XU535 NOR2X2 $PINS A=A[28] B=n262 Y=n86
XU536 CLKINVX3 $PINS A=n141 Y=n140
XU537 AOI21X1 $PINS A0=n429 A1=n168 B0=n163 Y=n161
XU538 NOR2X1 $PINS A=n102 B=n107 Y=n96
XU539 NAND2X1 $PINS A=A[22] B=n268 Y=n125
XU540 OR2X1 $PINS A=A[5] B=n285 Y=n436
XU541 INVX1 $PINS A=B[10] Y=n280
XU542 NAND2X1 $PINS A=A[32] B=n258 Y=n59
XU543 NAND2XL $PINS A=n432 B=n170 Y=n22
XU544 NAND2X1 $PINS A=A[26] B=n264 Y=n103
XU545 INVX1 $PINS A=n170 Y=n168
XU546 NAND2X1 $PINS A=A[5] B=n285 Y=n208
XU547 XNOR2X1 $PINS A=B[1] B=p1 Y=DIFF[1]
XU548 XOR2X4 $PINS A=n95 B=n422 Y=DIFF[27]
XU549 XOR2X4 $PINS A=n104 B=n424 Y=DIFF[26]
XU551 NAND2XL $PINS A=n435 B=n200 Y=n29
XU552 XOR2X4 $PINS A=n76 B=n425 Y=DIFF[30]
XU553 XNOR2X1 $PINS A=n31 B=n209 Y=DIFF[5]
XU554 NOR2X2 $PINS A=n79 B=n74 Y=n68
XU555 NAND2XL $PINS A=A[4] B=n286 Y=n211
XU556 XOR2X4 $PINS A=n17 B=n140 Y=DIFF[19]
XU557 INVX1 $PINS A=n54 Y=n52
XU558 NAND2X1 $PINS A=n428 B=n147 Y=n18
XU560 XNOR2X2 $PINS A=n159 B=n20 Y=DIFF[16]
XU561 INVX1 $PINS A=n200 Y=n198
XU563 OR2X4 $PINS A=A[18] B=n272 Y=n428
XU564 OR2X2 $PINS A=A[14] B=n276 Y=n432
XU565 NAND2X1 $PINS A=A[20] B=n270 Y=n136
XU566 NAND2X1 $PINS A=A[24] B=n266 Y=n114
XU567 NAND2X1 $PINS A=A[18] B=n272 Y=n147
XU568 NAND2X1 $PINS A=A[14] B=n276 Y=n170
XU569 OR2X2 $PINS A=A[16] B=n274 Y=n433
XU570 INVX1 $PINS A=n208 Y=n206
XU571 NAND2X1 $PINS A=n436 B=n208 Y=n31
XU572 XOR2X1 $PINS A=n32 B=n212 Y=DIFF[4]
XU573 NOR2X1 $PINS A=A[4] B=n286 Y=n210
XU574 XOR2X1 $PINS A=n33 B=n216 Y=DIFF[3]
XU575 INVX1 $PINS A=B[9] Y=n281
XU576 INVX1 $PINS A=B[7] Y=n283
XU577 NOR2X1 $PINS A=A[3] B=n287 Y=n214
XU578 OAI21XL $PINS A0=n220 A1=n218 B0=n219 Y=n217
XU579 XOR2X1 $PINS A=n34 B=n220 Y=DIFF[2]
XU580 INVX1 $PINS A=B[34] Y=n256
XU582 NAND2XL $PINS A=B[2] B=A[2] Y=n219
XU583 NOR2XL $PINS A=B[2] B=A[2] Y=n218
XU584 INVX8 $PINS A=n110 Y=n109
XU466 OAI2BB1X4 $PINS A0N=n439 A1N=n109 B0=n83 Y=n1
XU511 AND2X2 $PINS A=n84 B=n96 Y=n439
.ENDS

.SUBCKT CONV clk reset busy ready iaddr[11] iaddr[10] iaddr[9] iaddr[8]
+ iaddr[7] iaddr[6] iaddr[5] iaddr[4] iaddr[3] iaddr[2] iaddr[1] iaddr[0]
+ idata[19] idata[18] idata[17] idata[16] idata[15] idata[14] idata[13]
+ idata[12] idata[11] idata[10] idata[9] idata[8] idata[7] idata[6] idata[5]
+ idata[4] idata[3] idata[2] idata[1] idata[0] cwr caddr_wr[11] caddr_wr[10]
+ caddr_wr[9] caddr_wr[8] caddr_wr[7] caddr_wr[6] caddr_wr[5] caddr_wr[4]
+ caddr_wr[3] caddr_wr[2] caddr_wr[1] caddr_wr[0] cdata_wr[19] cdata_wr[18]
+ cdata_wr[17] cdata_wr[16] cdata_wr[15] cdata_wr[14] cdata_wr[13] cdata_wr[12]
+ cdata_wr[11] cdata_wr[10] cdata_wr[9] cdata_wr[8] cdata_wr[7] cdata_wr[6]
+ cdata_wr[5] cdata_wr[4] cdata_wr[3] cdata_wr[2] cdata_wr[1] cdata_wr[0] crd
+ caddr_rd[11] caddr_rd[10] caddr_rd[9] caddr_rd[8] caddr_rd[7] caddr_rd[6]
+ caddr_rd[5] caddr_rd[4] caddr_rd[3] caddr_rd[2] caddr_rd[1] caddr_rd[0]
+ cdata_rd[19] cdata_rd[18] cdata_rd[17] cdata_rd[16] cdata_rd[15] cdata_rd[14]
+ cdata_rd[13] cdata_rd[12] cdata_rd[11] cdata_rd[10] cdata_rd[9] cdata_rd[8]
+ cdata_rd[7] cdata_rd[6] cdata_rd[5] cdata_rd[4] cdata_rd[3] cdata_rd[2]
+ cdata_rd[1] cdata_rd[0] csel[2] csel[1] csel[0] SCAN_IN SCAN_OUT SCAN_EN
XDIODE_4 ANTENNA $PINS A=FE_DBTN1162_register_3_19
XDIODE_3 ANTENNA $PINS A=cdata_rd[3]
XDIODE_2 ANTENNA $PINS A=cdata_rd[2]
XDIODE_1 ANTENNA $PINS A=iaddr[11]
XFE_OFC2373_CMF0_8 BUFX4 $PINS A=CMF0[8] Y=FE_OFN6265_CMF0_8
XFE_OFC2372_i_caddr_wr_8 BUFX4 $PINS A=FE_OFN6264_i_caddr_wr_8 Y=caddr_wr[8]
XFE_OCPC2372_n4632 BUFXL $PINS A=n4632 Y=FE_OCPN2372_n4632
XFE_RC_776_0 OAI21X4 $PINS A0=FE_RN_19_0 A1=n4590 B0=FE_OFN5607_a_cnt_8
+ Y=FE_RN_403_0
XFE_RC_775_0 NAND3X2 $PINS A=FE_RN_403_0 B=n4584 C=n4585 Y=n1748
XFE_RC_774_0 AOI222X1 $PINS A0=FE_OCPN6203_n5238 A1=FE_OFN5575_register_6__3
+ B0=FE_OFN5653_n4656 B1=CMF1[3] C0=FE_OCPN6200_n5237 C1=register[7][3] Y=n5904
XFE_OCPC2347_n6634 BUFX8 $PINS A=n6634 Y=FE_OCPN2347_n6634
XFE_OCPC2346_n5238 BUFX2 $PINS A=FE_OCPN6203_n5238 Y=FE_OCPN2346_n5238
XFE_RC_773_0 INVX4 $PINS A=FE_RN_182_0 Y=FE_RN_402_0
XFE_RC_772_0 NOR2X4 $PINS A=FE_RN_402_0 B=n4932 Y=FE_OCPN5436_n4528
XFE_RC_771_0 INVX2 $PINS A=n4932 Y=FE_RN_401_0
XFE_RC_770_0 NAND3X4 $PINS A=FE_RN_333_0 B=FE_RN_401_0 C=n4566 Y=n4541
XFE_OCPC2345_n6634 BUFX8 $PINS A=n6634 Y=FE_OCPN2345_n6634
XFE_RC_769_0 INVX4 $PINS A=n4718 Y=FE_RN_400_0
XFE_RC_768_0 NOR2X4 $PINS A=FE_RN_400_0 B=n5870 Y=n5341
XFE_OCPC2344_n6634 BUFX2 $PINS A=n6634 Y=FE_OCPN2344_n6634
XFE_RC_767_0 AOI21X2 $PINS A0=n6682 A1=FE_RN_17 B0=FE_OFN5760_FE_RN_74_0
+ Y=n4594
XFE_RC_766_0 INVX1 $PINS A=n5755 Y=FE_RN_399_0
XFE_RC_765_0 NAND2X4 $PINS A=FE_RN_399_0 B=n4786 Y=n6770
XFE_RC_764_0 CLKINVX4 $PINS A=FE_RN_398_0 Y=n4550
XFE_RC_763_0 NAND3X2 $PINS A=FE_RN_274_0 B=FE_RN_384_0 C=FE_RN_275_0
+ Y=FE_RN_398_0
XFE_OCPC2370_n5227 CLKBUFX8 $PINS A=n5227 Y=FE_OCPN6262_n5227
XFE_RC_762_0 CLKINVX3 $PINS A=n4718 Y=FE_RN_397_0
XFE_RC_761_0 NOR2X4 $PINS A=FE_RN_397_0 B=n5872 Y=n5342
XFE_RC_760_0 AOI222X2 $PINS A0=FE_OCPN2342_n5238 A1=FE_DBTN63_register_6_5
+ B0=FE_OFN5653_n4656 B1=CMF1[5] C0=FE_OCPN6200_n5237 C1=FE_OFN5581_register_7__5
+ Y=n5900
XFE_RC_759_0 OAI222XL $PINS A0=FE_OFN5704_n4378 A1=n6689 B0=n4355 B1=n6711
+ C0=n4356 C1=n6619 Y=n1948
XFE_RC_757_0 AOI22X1 $PINS A0=FE_OCPN6203_n5238 A1=n5321 B0=FE_OFN5653_n4656
+ B1=FE_OFN5631_CMF1_0 Y=FE_RN_395_0
XFE_RC_756_0 NAND4X1 $PINS A=FE_OFN5946_FE_DBTN7_n5276 B=n4384 C=n6652 D=n4443
+ Y=n4525
XFE_OCPC2369_n5636 CLKBUFX8 $PINS A=n5636 Y=FE_OCPN6261_n5636
XFE_OCPC2368_n5230 CLKBUFX8 $PINS A=n5230 Y=FE_OCPN6260_n5230
XFE_RC_755_0 NAND2X1 $PINS A=FE_OFN5848_FE_DBTN21_N1711 B=FE_OCPN6200_n5237
+ Y=FE_RN_394_0
XFE_RC_753_0 AND2X2 $PINS A=FE_RN_395_0 B=FE_RN_394_0 Y=FE_RN_396_0
XFE_RC_752_0 NAND2X2 $PINS A=n5912 B=FE_RN_396_0 Y=n1724
XFE_RC_751_0 NAND2X1 $PINS A=FE_OCPN6258_FE_OFN444_n5346 B=n54 Y=FE_RN_392_0
XFE_RC_750_0 CLKINVX2 $PINS A=FE_RN_393_0 Y=n4605
XFE_RC_749_0 OAI21X1 $PINS A0=FE_RN_326_0 A1=FE_RN_325_0 B0=FE_RN_392_0
+ Y=FE_RN_393_0
XFE_RC_748_0 AOI22X2 $PINS A0=FE_RN_17 A1=n6670 B0=n4932 B1=n6671 Y=n4568
XFE_RC_747_0 INVX1 $PINS A=CMF1[35] Y=FE_RN_390_0
XFE_RC_746_0 INVX4 $PINS A=n5919 Y=FE_RN_391_0
XFE_RC_745_0 OAI21X4 $PINS A0=FE_RN_391_0 A1=FE_RN_390_0 B0=n5920 Y=n5824
XFE_RC_744_0 OR2X4 $PINS A=n4535 B=n4611 Y=FE_RN_376_0
XFE_RC_743_0 OR3X4 $PINS A=n6639 B=FE_RN_179_0 C=n4316 Y=n4567
XFE_RC_742_0 INVX2 $PINS A=FE_RN_249_0 Y=FE_RN_389_0
XFE_RC_741_0 NOR2X4 $PINS A=FE_RN_389_0 B=FE_OFN394_n4528 Y=FE_RN_323_0
XFE_OCPC2367_FE_OFN444_n5346 BUFX8 $PINS A=FE_OFN444_n5346
+ Y=FE_OCPN6259_FE_OFN444_n5346
XFE_OCPC2366_FE_OFN444_n5346 BUFX4 $PINS A=FE_OFN444_n5346
+ Y=FE_OCPN6258_FE_OFN444_n5346
XFE_OCPC2343_FE_RN_101_0 BUFXL $PINS A=FE_RN_101_0 Y=FE_OCPN2343_FE_RN_101_0
XFE_RC_739_0 AND2X2 $PINS A=FE_RN_312_0 B=n4245 Y=FE_RN_388_0
XFE_RC_738_0 OAI2BB2X4 $PINS A0N=FE_RN_388_0 A1N=FE_RN_294_0 B0=FE_RN_75_0
+ B1=FE_DBTN7_n5276 Y=n5673
XFE_OCPC2342_n5238 BUFX2 $PINS A=FE_OCPN6203_n5238 Y=FE_OCPN2342_n5238
XFE_RC_735_0 INVX1 $PINS A=n4535 Y=FE_RN_386_0
XFE_RC_734_0 NAND2X2 $PINS A=FE_RN_386_0 B=n4620 Y=FE_RN_249_0
XFE_OCPC2341_n5341 BUFX3 $PINS A=n5341 Y=FE_OCPN2341_n5341
XFE_RC_733_0_dup AOI2BB2X4 $PINS A0N=FE_DBTN1186_FE_RN_5 A1N=n5288
+ B0=FE_OFN5946_FE_DBTN7_n5276 B1=n4445 Y=FE_RN_11
XFE_OCPC2340_FE_RN_10 BUFX8 $PINS A=FE_RN_10 Y=FE_OCPN2340_FE_RN_10
XFE_RC_733_0 AOI2BB2X4 $PINS A0N=FE_DBTN1186_FE_RN_5 A1N=n5288
+ B0=FE_OFN5946_FE_DBTN7_n5276 B1=n4445 Y=n4524
XFE_RC_731_0 AND2X2 $PINS A=FE_OCPN6203_n5238 B=register[6][12] Y=FE_RN_385_0
XFE_RC_730_0 AOI221X2 $PINS A0=FE_OCPN6199_n5237 A1=FE_OFN5580_register_7__12
+ B0=FE_OFN5653_n4656 B1=CMF1[12] C0=FE_RN_385_0 Y=n5886
XFE_RC_729_0 INVX1 $PINS A=FE_RN_139_0 Y=FE_RN_384_0
XFE_OCPC2339_FE_RN_7 BUFXL $PINS A=FE_RN_7 Y=FE_OCPN2339_FE_RN_7
XFE_OCPC2337_n5904 BUFX3 $PINS A=n5904 Y=FE_OCPN2337_n5904
XFE_OCPC2365_FE_RN_6 CLKBUFX3 $PINS A=FE_RN_6 Y=FE_OCPN6257_FE_RN_6
XFE_RC_727_0 NOR2X4 $PINS A=FE_RN_5 B=FE_OFN5651_n4638 Y=n4932
XFE_OCPC2364_FE_RN_294_0 INVX1 $PINS A=FE_RN_1 Y=FE_OCPN1114_n4350
XFE_OCPC2363_FE_RN_294_0 CLKBUFX4 $PINS A=FE_RN_294_0 Y=FE_RN_1
XFE_RC_726_0 AOI222X2 $PINS A0=FE_OCPN6248_FE_DBTN1185_n4720
+ A1=FE_OFN6265_CMF0_8 B0=FE_OFN6151_n5224 B1=FE_OFN5750_register_2__8
+ C0=FE_OCPN6193_n5223 C1=FE_OFN5936_N612 Y=n5735
XFE_OCPC2336_n5002 BUFXL $PINS A=FE_OCPN6195_n5002 Y=FE_OCPN2336_n5002
XFE_OCPC2361_n5001 INVX4 $PINS A=FE_OCPN6254_n5001 Y=FE_OCPN6255_n5001
XFE_OCPC2360_n5001 CLKINVX4 $PINS A=n5001 Y=FE_OCPN6254_n5001
XFE_OCPC2335_FE_OFN5946_FE_DBTN7_n5276 BUFXL $PINS A=FE_OFN5946_FE_DBTN7_n5276
+ Y=FE_OCPN2335_FE_OFN5946_FE_DBTN7_n5276
XFE_OCPC2334_n5002 BUFXL $PINS A=FE_OCPN6195_n5002 Y=FE_OCPN2334_n5002
XFE_RC_724_0 AND2X2 $PINS A=FE_OCPN6248_FE_DBTN1185_n4720 B=FE_OFN5617_CMF0_9
+ Y=FE_RN_383_0
XFE_RC_723_0 AOI221X1 $PINS A0=FE_OFN6151_n5224 A1=FE_OFN5539_register_2__9
+ B0=FE_OCPN6193_n5223 B1=n5103 C0=FE_RN_383_0 Y=n5733
XFE_OCPC2359_n5897 CLKBUFX8 $PINS A=n5897 Y=FE_OCPN6253_n5897
XFE_RC_722_0 NAND2X1 $PINS A=n4534 B=n4387 Y=FE_RN_380_0
XFE_RC_721_0 NAND2X1 $PINS A=FE_OFN394_n4528 B=N8545 Y=FE_RN_381_0
XFE_RC_720_0 CLKINVX3 $PINS A=FE_RN_382_0 Y=n4601
XFE_RC_719_0 NAND3BX2 $PINS AN=n6636 B=FE_RN_381_0 C=FE_RN_380_0 Y=FE_RN_382_0
XFE_RC_718_0 NAND3X4 $PINS A=FE_RN_294_0 B=n4245 C=FE_RN_312_0 Y=n4645
XFE_OCPC2358_n4465 CLKBUFX3 $PINS A=n4465 Y=FE_OCPN6252_n4465
XFE_RC_715_0 NAND3X2 $PINS A=n4592 B=FE_RN_112_0 C=FE_OFN5667_n4546 Y=n1745
XFE_OCPC2357_n5232 CLKBUFX8 $PINS A=n5232 Y=FE_OCPN6251_n5232
XFE_RC_443_0_dup CLKINVX8 $PINS A=FE_RN_253_0 Y=FE_RN_5
XFE_OCPC2332_FE_OFN5639_FE_RN_194_0 BUFXL $PINS A=FE_OFN5639_FE_RN_194_0
+ Y=FE_OCPN2332_FE_OFN5639_FE_RN_194_0
XFE_RC_714_0 OR2X2 $PINS A=n6690 B=FE_RN_292_0 Y=FE_RN_378_0
XFE_RC_713_0 NOR2X4 $PINS A=FE_RN_378_0 B=FE_RN_331_0 Y=FE_RN_332_0
XFE_OCPC2356_n5505 BUFX8 $PINS A=n5505 Y=FE_OCPN6250_n5505
XFE_RC_711_0 CLKINVX4 $PINS A=FE_RN_305_0 Y=FE_RN_377_0
XFE_RC_710_0 NAND2X4 $PINS A=FE_RN_377_0 B=n4550 Y=n4542
XFE_OCPC2355_n5223 BUFX12 $PINS A=n5223 Y=FE_OCPN6193_n5223
XFE_OCPC2353_n4567 INVX1 $PINS A=n6634 Y=FE_OCPN6249_n4567
XFE_OCPC2352_n4567 CLKINVX3 $PINS A=n6634 Y=FE_OFN6173_n4567
XFE_OCPC2351_n4567 INVX8 $PINS A=n4567 Y=n6634
XFE_OCPC2350_n5232 CLKBUFX4 $PINS A=n5232 Y=FE_OFN6171_n5232
XFE_OCPC2331_FE_RN_2 BUFXL $PINS A=FE_RN_2 Y=FE_OCPN2331_FE_RN_2
XFE_OCPC2348_n5006 INVX8 $PINS A=FE_RN_270_0 Y=FE_OFN6148_n5006
XFE_OCPC2347_n5006 INVX8 $PINS A=n5006 Y=FE_RN_270_0
XFE_OCPC2346_n4910 BUFX4 $PINS A=n5834 Y=FE_OCPN6243_n5834
XFE_OCPC2345_n4910 INVX4 $PINS A=n4910 Y=n5834
XFE_RC_707_0 OAI211X2 $PINS A0=FE_RN_9 A1=n4606 B0=FE_OCPN5436_n4528
+ C0=FE_RN_376_0 Y=n4615
XFE_RC_706_0 NAND3X2 $PINS A=n4575 B=n4574 C=FE_OFN5667_n4546 Y=n1751
XFE_RC_705_0 OAI2BB1X4 $PINS A0N=FE_RN_337_0 A1N=FE_RN_171_0 B0=FE_RN_170_0
+ Y=FE_RN_173_0
XFE_RC_704_0 OAI21X2 $PINS A0=FE_RN_245_0 A1=n4621 B0=FE_RN_244_0 Y=FE_RN_246_0
XFE_RC_703_0 NAND2X1 $PINS A=FE_OCPN6257_FE_RN_6 B=FE_OCPN6209_register_5__2
+ Y=FE_RN_373_0
XFE_RC_702_0 AOI22X1 $PINS A0=n5341 A1=FE_OFN5557_register_4__2
+ B0=FE_OFN5978_n5340 B1=n130 Y=FE_RN_374_0
XFE_RC_701_0 AND2X4 $PINS A=FE_RN_374_0 B=FE_RN_373_0 Y=n5907
XFE_RC_700_0 NAND3X2 $PINS A=FE_RN_148_0 B=FE_RN_152_0 C=FE_RN_147_0 Y=n1754
XFE_RC_699_0 OAI21X4 $PINS A0=FE_OFN6056_FE_RN_5 A1=n4483 B0=n4449 Y=n5349
XFE_RC_698_0 NAND2X1 $PINS A=n4315 B=n4316 Y=FE_RN_372_0
XFE_RC_697_0 NOR2BX4 $PINS AN=FE_RN_1 B=FE_RN_372_0 Y=n4999
XFE_OCPC2344_i_ready CLKINVX8 $PINS A=ready Y=FE_RN_27
XFE_OCPC2343_FE_DBTN1185_n4720 BUFX12 $PINS A=FE_DBTN1185_n4720
+ Y=FE_OCPN6248_FE_DBTN1185_n4720
XFE_RC_695_0 OAI22X1 $PINS A0=FE_OFN6056_FE_RN_5 A1=n6698
+ B0=FE_OCPN6197_FE_DBTN7_n5276 B1=n4442 Y=FE_RN_371_0
XFE_RC_694_0 NAND2BX4 $PINS AN=FE_RN_371_0 B=FE_OFN5649_n4407 Y=n5351
XFE_RC_693_0 NAND2X1 $PINS A=FE_OFN5653_n4656 B=CMF1[1] Y=FE_RN_368_0
XFE_RC_692_0 NAND2X1 $PINS A=FE_OCPN6203_n5238 B=FE_OFN5600_N872 Y=FE_RN_369_0
XFE_RC_691_0 NAND2X1 $PINS A=FE_RN_369_0 B=FE_RN_368_0 Y=FE_RN_370_0
XFE_RC_690_0 NOR2X2 $PINS A=FE_RN_308_0 B=FE_RN_370_0 Y=n5908
XFE_OCPC2331_i_reset_dup BUFX20 $PINS A=reset Y=FE_RN_2
XFE_RC_688_0 NAND3X4 $PINS A=n4578 B=n4576 C=n4577 Y=n4573
XFE_OCPC2342_n5002 BUFX8 $PINS A=FE_OCPN6195_n5002 Y=FE_OCPN6247_n
XFE_RC_687_0 NAND3X2 $PINS A=FE_RN_169_0 B=FE_RN_173_0 C=FE_RN_166_0 Y=n1758
XFE_RC_686_0 OAI21XL $PINS A0=FE_RN_9 A1=FE_RN_223_0 B0=FE_RN_222_0
+ Y=FE_RN_318_0
XFE_RC_685_0 AOI222X1 $PINS A0=FE_OCPN6193_n5223 A1=FE_OFN5548_register_3__11
+ B0=FE_OFN6151_n5224 B1=FE_OFN5537_register_2__11
+ C0=FE_OCPN6248_FE_DBTN1185_n4720 C1=FE_OFN5615_CMF0_11 Y=n5729
XFE_RC_684_0 AND2X2 $PINS A=FE_OCPN6193_n5223 B=FE_OFN6168_N607 Y=FE_RN_367_0
XFE_RC_683_0 NOR2X4 $PINS A=FE_RN_367_0 B=FE_RN_301_0 Y=n5745
XFE_RC_682_0 AOI222X2 $PINS A0=FE_OCPN6200_n5237 A1=register[7][4]
+ B0=FE_OFN5653_n4656 B1=CMF1[4] C0=FE_OCPN6203_n5238 C1=FE_DBTN62_register_6_4
+ Y=n5902
XFE_OCPC2340_n5352 CLKBUFX3 $PINS A=n5352 Y=FE_OCPN6245_n5352
XFE_RC_681_0 NAND2X1 $PINS A=FE_OCPN6247_n B=FE_DBTN22_n5504 Y=FE_RN_364_0
XFE_RC_680_0 NAND2X1 $PINS A=FE_OFN6130_n5000 B=n226 Y=FE_RN_365_0
XFE_RC_679_0 NAND2X1 $PINS A=FE_OFN6125_n5007 B=register[0][1] Y=FE_RN_366_0
XFE_RC_678_0 AND3X2 $PINS A=FE_RN_366_0 B=FE_RN_365_0 C=FE_RN_364_0 Y=n5750
XFE_RC_677_0 AOI22X2 $PINS A0=FE_OCPN6199_n5237 A1=register[7][6]
+ B0=FE_OFN5653_n4656 B1=CMF1[6] Y=FE_RN_264_0
XFE_OCPC2339_n5352 CLKBUFX8 $PINS A=n5352 Y=FE_OCPN6244_n5352
XFE_RC_676_0 OAI211X2 $PINS A0=n4603 A1=n6685 B0=n4604 C0=n4605 Y=n1739
XFE_RC_675_0 INVX8 $PINS A=FE_RN_363_0 Y=n5330
XFE_RC_674_0 NOR2X4 $PINS A=FE_OFN5677_n5350 B=n5566 Y=FE_RN_363_0
XFE_OCPC2337_FE_OFN6056_FE_RN_5 CLKBUFX3 $PINS A=FE_OFN6056_FE_RN_5
+ Y=FE_OCPN6242_FE_OFN6056_FE_RN_5
XFE_OCPC2336_FE_OFN6056_FE_RN_5 BUFX3 $PINS A=FE_OFN6056_FE_RN_5
+ Y=FE_OCPN6241_FE_OFN6056_FE_RN_5
XFE_OCPC2335_FE_DBTN7_n5276 BUFX12 $PINS A=FE_DBTN7_n5276
+ Y=FE_OCPN6240_FE_DBTN7_n5276
XFE_RC_673_0 NAND4X4 $PINS A=FE_RN_257_0 B=FE_RN_106_0 C=FE_RN_11 D=FE_RN_101_0
+ Y=FE_RN_74_0
XFE_RC_669_0 AND2X2 $PINS A=n5919 B=FE_OFN5611_CMF0_15 Y=FE_RN_360_0
XFE_RC_668_0 NOR2X4 $PINS A=n5678 B=FE_RN_360_0 Y=n4911
XFE_OCPC2331_i_reset BUFX20 $PINS A=reset Y=FE_OCPN6236_i_reset
XFE_RC_667_0 INVX1 $PINS A=register[7][2] Y=FE_RN_358_0
XFE_RC_666_0 CLKINVX8 $PINS A=FE_RN_359_0 Y=n5243
XFE_RC_665_0 MX2X2 $PINS S0=n5671 B=register[7][2] A=FE_RN_358_0 Y=FE_RN_359_0
XFE_RC_663_0 INVX1 $PINS A=n5110 Y=FE_RN_357_0
XFE_RC_662_0 MX2X4 $PINS S0=n5113 B=FE_RN_357_0 A=n5110 Y=r2257/DIFF[2]
XFE_OCPC2329_register_5__4 BUFX3 $PINS A=register[5][4]
+ Y=FE_OCPN6233_register_5__4
XFE_OCPC2325_N1281 BUFX4 $PINS A=N1281 Y=FE_OCPN6229_N1281
XFE_RC_653_0 CLKINVX3 $PINS A=FE_RN_353_0 Y=n5281
XFE_RC_652_0 NAND4X1 $PINS A=FE_DBTN137_register_0_3 B=n5761 C=n5114 D=n5760
+ Y=FE_RN_353_0
XFE_OCPC2318_n5279 BUFX3 $PINS A=n5279 Y=FE_OCPN6222_n5279
XFE_RC_649_0 XOR2X4 $PINS A=n5669 B=register[7][4] Y=r2240/DIFF[4]
XFE_RC_647_0 AND2X2 $PINS A=FE_OFN5932_register_5__8 B=FE_DBTN81_register_5_10
+ Y=FE_RN_352_0
XFE_RC_646_0 NAND3X4 $PINS A=FE_RN_352_0 B=n5236 C=FE_OFN5816_register_5__7
+ Y=n5557
XFE_RC_644_0 INVX8 $PINS A=FE_RN_351_0 Y=n5269
XFE_RC_643_0 AOI2BB2X2 $PINS A0N=FE_OFN5850_FE_DBTN21_N1711 A1N=n5672
+ B0=FE_OFN5850_FE_DBTN21_N1711 B1=n5672 Y=FE_RN_351_0
XFE_OCPC2314_N1145 BUFX16 $PINS A=register[1][2] Y=N1145
XFE_OCPC2309_register_7__2 BUFX3 $PINS A=register[7][2]
+ Y=FE_OCPN6213_register_7__2
XFE_RC_637_0 OR2X2 $PINS A=n5125 B=n5130 Y=FE_RN_346_0
XFE_RC_636_0 OR2X2 $PINS A=FE_OFN6145_n4911 B=n5127 Y=FE_RN_347_0
XFE_RC_635_0 OAI211X1 $PINS A0=n5128 A1=FE_OFN6158_n6762 B0=FE_RN_347_0
+ C0=FE_RN_346_0 Y=n5126
XFE_OCPC2308_register_4__7 BUFX3 $PINS A=register[4][7]
+ Y=FE_OCPN6212_register_4__7
XFE_OCPC2306_register_3__15 BUFX3 $PINS A=register[3][15]
+ Y=FE_OCPN6210_register_3__15
XFE_OCPC2305_register_5__2 BUFX3 $PINS A=register[5][2]
+ Y=FE_OCPN6209_register_5__2
XFE_OCPC2304_N1316 BUFX3 $PINS A=N1316 Y=FE_OCPN6208_N1316
XFE_RC_625_0 INVX1 $PINS A=n6751 Y=FE_RN_340_0
XFE_RC_624_0 MX2X4 $PINS S0=FE_DBTN54_register_7_9 B=FE_RN_340_0 A=n6751
+ Y=FE_OFN5416_r2240_DIFF_9
XFE_RC_623_0 NAND2X1 $PINS A=FE_OFN5804_N1316 B=FE_OCPN6229_N1281 Y=FE_RN_338_0
XFE_RC_622_0 NAND2BX1 $PINS AN=FE_OCPN6229_N1281 B=FE_RN_286_0 Y=FE_RN_339_0
XFE_RC_621_0 AND2X2 $PINS A=FE_RN_339_0 B=FE_RN_338_0 Y=r2236/DIFF[1]
XFE_RC_620_0 OAI222X1 $PINS A0=n5125 A1=n5124 B0=FE_OFN6145_n4911 B1=n5122
+ C0=n5123 C1=FE_OFN6158_n6762 Y=n5120
XCTS_ccl_a_buf_00012 CLKBUFX20 $PINS A=clk Y=CTS_2
XCTS_ccl_a_buf_00010 CLKBUFX20 $PINS A=clk Y=CTS_1
XCTS_ccl_a_buf_00008 CLKBUFX20 $PINS A=clk Y=CTS_5
XCTS_ccl_a_buf_00006 CLKBUFX20 $PINS A=clk Y=CTS_4
XFE_RC_619_0 NAND2X2 $PINS A=FE_OFN5604_a_cnt_11 B=n4543 Y=FE_RN_337_0
XFE_RC_617_0 INVX4 $PINS A=n4645 Y=FE_RN_336_0
XFE_RC_616_0 AOI21X4 $PINS A0=FE_OFN5946_FE_DBTN7_n5276 A1=FE_RN_141_0
+ B0=FE_RN_336_0 Y=FE_RN_257_0
XFE_RC_615_0 AOI22X2 $PINS A0=FE_RN_3 A1=n6678 B0=n6775 B1=n4582 Y=n4593
XFE_OCPC2279_FE_RN_29 BUFX4 $PINS A=FE_RN_29 Y=FE_OCPN2279_FE_RN_29
XFE_OCPC2278_FE_OFN5639_FE_RN_194_0 BUFXL $PINS A=FE_OFN5639_FE_RN_194_0
+ Y=FE_OCPN2278_FE_OFN5639_FE_RN_194_0
XFE_OCPC2276_n4632 BUFXL $PINS A=n4632 Y=FE_OCPN2276_n4632
XFE_RC_614_0 AOI22X2 $PINS A0=FE_RN_3 A1=n4557 B0=FE_RN_17 B1=n4558 Y=n4548
XFE_OCPC2275_FE_RN_106_0 BUFX1 $PINS A=FE_RN_106_0 Y=FE_OCPN2275_FE_RN_106_0
XFE_RC_613_0 NAND2X1 $PINS A=FE_OCPN6195_n5002 B=FE_OFN5525_register_1__8
+ Y=FE_RN_334_0
XFE_RC_612_0 AOI22X1 $PINS A0=FE_OFN6125_n5007 A1=FE_DBTN140_register_0_8
+ B0=FE_OFN6130_n5000 B1=n219 Y=FE_RN_335_0
XFE_RC_611_0 AND2X4 $PINS A=FE_RN_335_0 B=FE_RN_334_0 Y=n5736
XFE_RC_610_0 NOR2X2 $PINS A=FE_OCPN2344_n6634 B=n4559 Y=FE_RN_10
XFE_RC_609_0 NOR2X4 $PINS A=n4559 B=FE_OCPN2347_n6634 Y=FE_RN_333_0
XFE_OCPC2297_n5238 BUFX16 $PINS A=n5238 Y=FE_OCPN6203_n5238
XFE_RC_605_0 NOR2X4 $PINS A=FE_RN_2 B=FE_RN_27 Y=FE_RN_331_0
XFE_RC_604_0 INVX8 $PINS A=FE_RN_332_0 Y=FE_DBTN1186_FE_RN_5
XFE_RC_602_0 AOI22X1 $PINS A0=FE_OCPN6247_n A1=FE_OFN5998_register_1__0
+ B0=FE_OFN6130_n5000 B1=n227 Y=FE_RN_328_0
XFE_RC_601_0 NAND2X1 $PINS A=FE_OFN6125_n5007 B=FE_DBTN1180_N1618 Y=FE_RN_329_0
XFE_RC_600_0 AND2X4 $PINS A=FE_RN_329_0 B=FE_RN_328_0 Y=n5753
XFE_RC_599_0 NAND2X4 $PINS A=FE_OFN5639_FE_RN_194_0 B=n6647 Y=FE_RN_327_0
XFE_RC_598_0 NAND2X4 $PINS A=FE_DBTN1186_FE_RN_5 B=FE_RN_327_0 Y=n6646
XFE_OCPC2294_n4560 CLKINVX3 $PINS A=FE_OCPN5439_FE_OFN244_n4560
+ Y=FE_OFN5698_n4560
XFE_OCPC2292_n4560 INVX8 $PINS A=n4560 Y=FE_OCPN5439_FE_OFN244_n4560
XFE_OCPC2291_n5237 BUFX16 $PINS A=n5237 Y=FE_OCPN6200_n5237
XFE_OCPC2290_n5237 CLKBUFX8 $PINS A=n5237 Y=FE_OCPN6199_n5237
XFE_OCPC2288_FE_DBTN7_n5276 BUFX8 $PINS A=FE_DBTN7_n5276
+ Y=FE_OCPN6197_FE_DBTN7_n5276
XFE_OCPC2286_n6770 INVX8 $PINS A=n6770 Y=FE_OCPN6195_n5002
XFE_RC_597_0 INVX1 $PINS A=n4606 Y=FE_RN_325_0
XFE_RC_596_0 INVX1 $PINS A=n6630 Y=FE_RN_326_0
XFE_RC_594_0 NAND2X1 $PINS A=FE_RN_137_0 B=FE_OFN5698_n4560 Y=FE_RN_324_0
XFE_RC_593_0 NAND2X1 $PINS A=FE_RN_324_0 B=FE_RN_38_0 Y=FE_RN_222_0
XFE_OCPC2285_FE_RN_74_0 BUFX3 $PINS A=n6639 Y=FE_OFN5760_FE_RN_74_0
XFE_OCPC2284_FE_RN_74_0 CLKINVX8 $PINS A=FE_RN_74_0 Y=n6639
XFE_RC_590_0 OAI22X4 $PINS A0=n6637 A1=FE_RN_140_0 B0=FE_RN_5 B1=FE_RN_142_0
+ Y=n4559
XFE_RC_588_0 NAND2X4 $PINS A=FE_RN_323_0 B=FE_RN_248_0 Y=FE_RN_250_0
XFE_RC_587_0 INVX8 $PINS A=FE_RN_322_0 Y=n5233
XFE_RC_586_0 NAND2X2 $PINS A=FE_RN_29 B=FE_OFN5796_n4440 Y=FE_RN_322_0
XFE_RC_585_0 NOR2X4 $PINS A=FE_RN_81_0 B=FE_RN_82_0 Y=FE_RN_321_0
XFE_RC_584_0 NAND2X4 $PINS A=FE_RN_321_0 B=FE_OFN5649_n4407 Y=n5350
XFE_RC_581_0 INVX1 $PINS A=n48 Y=FE_RN_319_0
XFE_RC_580_0 NOR2BX1 $PINS AN=FE_OFN444_n5346 B=FE_RN_319_0 Y=FE_RN_320_0
XFE_RC_579_0 NOR2X2 $PINS A=n4581 B=FE_RN_320_0 Y=n4585
XFE_RC_577_0 NAND3BX2 $PINS AN=FE_RN_318_0 B=FE_RN_59_0 C=FE_RN_302_0
+ Y=FE_RN_303_0
XFE_RC_574_0 INVX1 $PINS A=n49 Y=FE_RN_315_0
XFE_RC_573_0 NOR2BX1 $PINS AN=FE_OCPN6259_FE_OFN444_n5346 B=FE_RN_315_0
+ Y=FE_RN_316_0
XFE_RC_572_0 AOI21X4 $PINS A0=n4590 A1=FE_OFN5608_a_cnt_7 B0=FE_RN_316_0
+ Y=n4592
XFE_RC_571_0 NAND2X1 $PINS A=FE_OFN6130_n5000 B=n221 Y=FE_RN_313_0
XFE_RC_570_0 OAI2BB1X1 $PINS A0N=register[0][6] A1N=FE_OFN6125_n5007
+ B0=FE_RN_313_0 Y=FE_RN_314_0
XFE_RC_569_0 AOI21X4 $PINS A0=FE_OCPN6247_n A1=FE_OFN6021_register_1__6
+ B0=FE_RN_314_0 Y=n5740
XFE_OCPC2279_n5348 BUFX3 $PINS A=n5348 Y=FE_OCPN6191_n5348
XFE_RC_567_0 NOR2BX4 $PINS AN=FE_RN_294_0 B=FE_RN_117_0 Y=n6663
XFE_RC_566_0 INVXL $PINS A=FE_RN_117_0 Y=FE_RN_312_0
XFE_RC_562_0 AND2X2 $PINS A=FE_OFN6125_n5007 B=FE_DBTN139_register_0_7
+ Y=FE_RN_310_0
XFE_RC_561_0 AOI22X1 $PINS A0=FE_OFN6130_n5000 A1=n220 B0=FE_OCPN6195_n5002
+ B1=FE_OFN5526_register_1__7 Y=FE_RN_311_0
XFE_RC_560_0 NOR2BX4 $PINS AN=FE_RN_311_0 B=FE_RN_310_0 Y=n5738
XFE_RC_559_0 OAI22X2 $PINS A0=FE_RN_15 A1=n4557 B0=FE_OFN5698_n4560 B1=n4555
+ Y=n4543
XFE_RC_556_0 AND2X2 $PINS A=FE_OCPN6200_n5237 B=FE_OFN6101_register_7__1
+ Y=FE_RN_308_0
XFE_RC_550_0 NAND2X2 $PINS A=n4548 B=n4549 Y=FE_RN_305_0
XFE_RC_548_0 NOR2X1 $PINS A=FE_OFN6173_n4567 B=n4551 Y=FE_RN_304_0
XFE_RC_547_0 AOI2BB1X4 $PINS A0N=n4566 A1N=n4554 B0=FE_RN_304_0 Y=FE_RN_22_0
XFE_RC_546_0 INVX1 $PINS A=n4626 Y=FE_RN_302_0
XFE_RC_545_0 CLKINVX4 $PINS A=FE_RN_303_0 Y=n4623
XFE_RC_543_0 NAND2X1 $PINS A=FE_OCPN6248_FE_DBTN1185_n4720 B=FE_OFN5621_CMF0_3
+ Y=FE_RN_299_0
XFE_RC_542_0 NAND2X1 $PINS A=FE_OFN6151_n5224 B=n5219 Y=FE_RN_300_0
XFE_RC_541_0 NAND2X1 $PINS A=FE_RN_300_0 B=FE_RN_299_0 Y=FE_RN_301_0
XFE_OCPC2276_n6646 BUFX4 $PINS A=n6646 Y=FE_OCPN6188_n6646
XFE_RC_539_0 NAND2X1 $PINS A=FE_OFN6130_n5000 B=n225 Y=FE_RN_296_0
XFE_RC_538_0 NAND2X1 $PINS A=FE_OCPN6247_n B=register[1][2] Y=FE_RN_297_0
XFE_RC_537_0 NAND2X1 $PINS A=FE_OFN6125_n5007 B=FE_OFN6132_n5113 Y=FE_RN_298_0
XFE_RC_536_0 AND3X2 $PINS A=FE_RN_298_0 B=FE_RN_297_0 C=FE_RN_296_0 Y=n5748
XFE_RC_535_0 AND2X2 $PINS A=FE_OFN5639_FE_RN_194_0 B=n4526 Y=FE_RN_295_0
XFE_RC_534_0 NOR2X4 $PINS A=FE_RN_31 B=FE_RN_295_0 Y=n4520
XFE_RC_533_0 INVX1 $PINS A=busy Y=FE_RN_292_0
XFE_RC_532_0 NOR2X4 $PINS A=FE_RN_2 B=FE_RN_27 Y=FE_RN_293_0
XFE_RC_530_0 NOR2X4 $PINS A=FE_RN_293_0 B=FE_RN_292_0 Y=FE_RN_294_0
XFE_RC_524_0 INVX1 $PINS A=n5551 Y=FE_RN_288_0
XFE_RC_523_0 MX2X4 $PINS S0=register[5][18] B=FE_RN_288_0 A=n5551
+ Y=r2236/DIFF[18]
XFE_RC_522_0 INVX1 $PINS A=FE_OFN5563_register_5__9 Y=FE_RN_287_0
XFE_RC_521_0 MXI2X1 $PINS S0=n5558 B=FE_OFN5563_register_5__9 A=FE_RN_287_0
+ Y=r2236/DIFF[9]
XFE_RC_520_0 INVX1 $PINS A=FE_OFN5804_N1316 Y=FE_RN_286_0
XFE_RC_505_0 INVX12 $PINS A=FE_RN_281_0 Y=r2240/DIFF[13]
XFE_RC_504_0 MX2X1 $PINS S0=n5658 B=FE_OFN5579_register_7__13
+ A=FE_DBTN57_register_7_13 Y=FE_RN_281_0
XFE_RC_503_0 NAND3X2 $PINS A=n4951 B=n4953 C=n4952 Y=n4935
XFE_RC_501_0 OR2X2 $PINS A=FE_OFN6082_n5272 B=n5154 Y=FE_RN_278_0
XFE_RC_500_0 OR2X2 $PINS A=FE_OCPN6243_n5834 B=n5152 Y=FE_RN_279_0
XFE_RC_499_0 OAI211X2 $PINS A0=n5153 A1=FE_OFN608_n5011 B0=FE_RN_279_0
+ C0=FE_RN_278_0 Y=n5151
XFE_OFC2251_N607 INVX1 $PINS A=FE_DBTN32_N607 Y=FE_OFN6168_N607
XFE_OFC2249_N607 INVX4 $PINS A=FE_OFN5589_N607 Y=FE_DBTN32_N607
XFE_OFC2248_N607 BUFX3 $PINS A=N607 Y=FE_OFN5589_N607
XFE_OFC2247_n4378 CLKINVX3 $PINS A=FE_OFN599_n4378 Y=FE_OFN5704_n4378
XFE_OFC2246_n5011 BUFX3 $PINS A=n5011 Y=FE_OFN6166_n5011
XFE_OFC2238_n6762 BUFX3 $PINS A=n5009 Y=FE_OFN6159_n6762
XFE_OFC2237_n6762 INVX1 $PINS A=n5009 Y=FE_OFN6158_n6762
XFE_OFC2236_n6762 INVX4 $PINS A=n6762 Y=n5009
XFE_OFC2230_n4906 BUFX3 $PINS A=n4931 Y=FE_OFN6157_n4906
XFE_OFC2226_n4906 INVX4 $PINS A=n4906 Y=n4931
XFE_OFC2223_n5224 BUFX12 $PINS A=n5224 Y=FE_OFN6151_n5224
XFE_OFC2221_n4905 BUFX4 $PINS A=n4982 Y=FE_OFN6150_n4905
XFE_OFC2219_n4905 INVX2 $PINS A=n4905 Y=n4982
XFE_OFC2215_n4911 INVX1 $PINS A=FE_OFN6142_n4911 Y=FE_OFN6146_n4911
XFE_OFC2214_n4911 INVX1 $PINS A=FE_OFN6093_n4911 Y=FE_OFN6145_n4911
XFE_OFC2213_n4911 INVX1 $PINS A=FE_OFN6093_n4911 Y=FE_OFN6144_n4911
XFE_OFC2211_n4911 INVX1 $PINS A=n5691 Y=FE_OFN6142_n4911
XFE_OFC2210_n4911 CLKINVX3 $PINS A=n5691 Y=FE_OFN6093_n4911
XFE_OFC2209_n4911 INVX4 $PINS A=n4911 Y=n5691
XFE_OFC2207_n4971 BUFX3 $PINS A=FE_OFN409_n4971 Y=FE_OFN6141_n
XFE_OFC2200_FE_DBTN21_N1711 INVX1 $PINS A=FE_OFN5850_FE_DBTN21_N1711
+ Y=FE_OFN5852_FE_DBTN21_N1711
XFE_OFC2199_FE_DBTN21_N1711 CLKINVX8 $PINS A=FE_OFN5850_FE_DBTN21_N1711 Y=N965
XFE_OFC2198_FE_DBTN21_N1711 CLKBUFX8 $PINS A=FE_DBTN21_N1711
+ Y=FE_OFN5850_FE_DBTN21_N1711
XFE_OFC2197_i_idata_11 INVX1 $PINS A=n5043 Y=FE_OFN6139_i_idata_11
XFE_OFC2196_i_idata_11 CLKINVX3 $PINS A=idata[11] Y=n5043
XFE_OFC2195_n5000 BUFX8 $PINS A=n5000 Y=FE_OFN6130_n5000
XFE_OFC2193_FE_RN_194_0 BUFX8 $PINS A=FE_OFN5639_FE_RN_194_0
+ Y=FE_OFN5946_FE_DBTN7_n5276
XFE_OFC2192_FE_RN_194_0 CLKINVX8 $PINS A=FE_OFN5639_FE_RN_194_0
+ Y=FE_DBTN7_n5276
XFE_OFC2191_FE_RN_194_0 INVX8 $PINS A=FE_RN_194_0 Y=FE_OFN5639_FE_RN_194_0
XFE_OFC2184_n5113 BUFX4 $PINS A=n5113 Y=FE_OFN6132_n5113
XFE_OFC2178_n5229 CLKBUFX8 $PINS A=n5229 Y=FE_OFN6126_n5229
XFE_OFC2177_n5007 BUFX20 $PINS A=n5007 Y=FE_OFN6125_n5007
XFE_OFC2159_n5352 CLKBUFX8 $PINS A=FE_OCPN6244_n5352 Y=FE_OFN6107_n5352
XFE_OFC2149_n5003 BUFX12 $PINS A=n5003 Y=FE_OFN5986_n5003
XFE_OFC2145_register_7__1 INVX1 $PINS A=n5672 Y=FE_OFN6101_register_7__1
XFE_OFC2144_register_7__1 INVX4 $PINS A=register[7][1] Y=n5672
XFE_OFC2136_n5843 INVX4 $PINS A=n5843 Y=n5915
XFE_OFC2132_register_2__9 CLKBUFX8 $PINS A=register[2][9]
+ Y=FE_OFN5539_register_2__9
XFE_OFC2131_n4911 INVX1 $PINS A=FE_OFN6145_n4911 Y=FE_OFN6095_n4911
XFE_OFC2130_n4911 INVXL $PINS A=FE_OFN6144_n4911 Y=FE_OFN6094_n4911
XFE_OFC2123_n4911 INVXL $PINS A=FE_OFN6146_n4911 Y=FE_OFN5644_n4911
XFE_OFC2116_n5396 CLKINVX3 $PINS A=n5396 Y=FE_OFN6087_n5396
XFE_OFC2115_n5396 INVX1 $PINS A=n5396 Y=FE_DBTN6_n5396
XFE_OFC2107_N1281 CLKINVX8 $PINS A=N1281 Y=FE_OFN5835_N1281
XFE_OFC2106_n5556 INVX1 $PINS A=n5556 Y=n5545
XFE_OFC2101_n5272 INVX1 $PINS A=n5272 Y=FE_OFN6082_n5272
XFE_OFC2094_n4908 INVX8 $PINS A=n4908 Y=n5318
XFE_OFC2090_FE_DBTN21_N1711 CLKBUFX3 $PINS A=N965 Y=FE_OFN5855_FE_DBTN21_N1711
XFE_OFC2088_FE_DBTN21_N1711 CLKINVX3 $PINS A=N965 Y=FE_OFN5853_FE_DBTN21_N1711
XFE_OFC2078_n6728 INVX1 $PINS A=FE_DBTN0_n6728 Y=FE_OFN6069_n6728
XFE_OFC2077_n6728 CLKINVX3 $PINS A=n6728 Y=FE_DBTN0_n6728
XFE_OFC2074_n4378 BUFX4 $PINS A=n4378 Y=FE_OFN599_n4378
XFE_OFC2073_register_4__12 BUFX3 $PINS A=FE_DBTN98_register_4_12
+ Y=FE_OFN6068_register_4__12
XFE_OFC2071_register_4__12 INVX1 $PINS A=register[4][12]
+ Y=FE_DBTN98_register_4_12
XFE_OFC2065_n4720 BUFX3 $PINS A=FE_OFN5656_n4720 Y=FE_DBTN1185_n4720
XFE_OFC2064_n4720 CLKINVX8 $PINS A=n4720 Y=FE_OFN5656_n4720
XFE_OFC2054_n4998 BUFX4 $PINS A=n4998 Y=FE_OFN5967_n4998
XFE_OFC2051_n5505 CLKINVX3 $PINS A=FE_OCPN6250_n5505 Y=FE_OFN5658_n5505
XFE_OFC2049_n4907 INVX4 $PINS A=n5314 Y=FE_OFN6060_n4907
XFE_OFC2048_n4907 CLKBUFX8 $PINS A=n4907 Y=n5314
XFE_OFC2047_n5678 CLKINVX8 $PINS A=n5678 Y=FE_RN_53_0
XFE_OFC2044_n5531 INVX1 $PINS A=FE_OFN5646_n5531 Y=FE_OFN6058_n5531
XFE_OFC2043_n5531 CLKINVX3 $PINS A=FE_OFN5646_n5531 Y=FE_OFN6057_n5531
XFE_OFC2042_n5531 INVXL $PINS A=FE_OFN5646_n5531 Y=FE_OFN5647_n5531
XFE_OFC2040_n5531 CLKINVX8 $PINS A=n5531 Y=FE_OFN5646_n5531
XFE_OFC2039_n5673 CLKINVX8 $PINS A=n5673 Y=n5920
XFE_OFC2038_n5231 BUFX12 $PINS A=n5231 Y=FE_OFN5983_n5231
XFE_OFC2037_FE_RN_5 BUFX8 $PINS A=FE_DBTN1186_FE_RN_5 Y=FE_OFN6056_FE_RN_5
XFE_OFC2034_FE_RN_5 INVX1 $PINS A=FE_OCPN6241_FE_OFN6056_FE_RN_5
+ Y=FE_OFN5687_FE_RN_5
XFE_OFC2029_n5348 CLKINVX8 $PINS A=n5348 Y=FE_OFN176_n5348
XFE_OFC2028_n5348 BUFX3 $PINS A=n5348 Y=FE_OFN5960_n5348
XFE_OFC2027_n4999 BUFX3 $PINS A=FE_OFN5662_n4999 Y=FE_OFN459_FE_DBTN5_n4999
XFE_OFC2026_n4999 CLKINVX8 $PINS A=n4999 Y=FE_OFN5662_n4999
XFE_OFC2020_register_0__14 BUFX4 $PINS A=register[0][14]
+ Y=FE_OFN6049_register_0__14
XFE_OFC2014_N1252 BUFX3 $PINS A=register[4][0] Y=N707
XFE_OFC2012_N1177 BUFX3 $PINS A=FE_OFN6039_N1177 Y=FE_OFN6040_N1177
XFE_OFC2010_register_2__5 CLKBUFX8 $PINS A=register[2][5]
+ Y=FE_OFN6038_register_2__5
XFE_OFC2008_register_8__11 BUFX4 $PINS A=register[8][11]
+ Y=FE_OFN6036_register_8__11
XFE_OFC2002_register_1__17 BUFX3 $PINS A=FE_OFN6029_register_1__17
+ Y=FE_OFN6030_register_1__17
XFE_OFC2001_register_1__17 CLKBUFX8 $PINS A=register[1][17]
+ Y=FE_OFN6029_register_1__17
XFE_OFC1998_register_8__7 BUFX3 $PINS A=register[8][7]
+ Y=FE_OFN6026_register_8__7
XFE_OFC1994_register_1__6 BUFX3 $PINS A=FE_OFN6021_register_1__6
+ Y=FE_OFN6022_register_1__6
XFE_OFC1993_register_1__6 BUFX8 $PINS A=register[1][6]
+ Y=FE_OFN6021_register_1__6
XFE_OFC1991_register_0__11 CLKBUFX8 $PINS A=register[0][11]
+ Y=FE_OFN6019_register_0__11
XFE_OFC1990_register_8__4 BUFX4 $PINS A=register[8][4]
+ Y=FE_OFN6018_register_8__4
XFE_OFC1989_register_3__17 BUFX3 $PINS A=register[3][17]
+ Y=FE_OFN6017_register_3__17
XFE_OFC1987_register_1__5 CLKBUFX8 $PINS A=register[1][5]
+ Y=FE_OFN6015_register_1__5
XFE_OFC1985_n5336 BUFX12 $PINS A=n5637 Y=FE_OFN6013_n5336
XFE_OFC1983_register_8__3 BUFX3 $PINS A=register[8][3]
+ Y=FE_OFN6011_register_8__3
XFE_OFC1980_register_3__19 BUFX3 $PINS A=register[3][19]
+ Y=FE_OFN6008_register_3__19
XFE_OFC1977_N999 BUFX3 $PINS A=N999 Y=FE_OFN6005_N999
XFE_OFC1975_register_1__10 CLKBUFX8 $PINS A=register[1][10]
+ Y=FE_OFN6003_register_1__10
XFE_OFC1974_register_1__11 CLKBUFX8 $PINS A=register[1][11]
+ Y=FE_OFN6002_register_1__11
XFE_OFC1971_register_1__0 CLKBUFX8 $PINS A=register[1][0]
+ Y=FE_OFN5998_register_1__0
XFE_OFC1970_register_1__12 CLKBUFX8 $PINS A=register[1][12]
+ Y=FE_OFN5997_register_1__12
XFE_OFC1968_n5018 BUFX12 $PINS A=n5018 Y=FE_OFN5995_n5018
XFE_OFC1966_register_8__15 BUFX3 $PINS A=register[8][15]
+ Y=FE_OFN5993_register_8__15
XFE_OFC1962_register_6__13 BUFX3 $PINS A=register[6][13]
+ Y=FE_OFN5989_register_6__13
XFE_OFC1957_register_6__15 BUFX3 $PINS A=register[6][15]
+ Y=FE_OFN5984_register_6__15
XFE_OFC1953_register_8__16 BUFX3 $PINS A=FE_OFN5979_register_8__16
+ Y=FE_OFN5980_register_8__16
XFE_OFC1952_register_8__16 BUFX3 $PINS A=register[8][16]
+ Y=FE_OFN5979_register_8__16
XFE_OFC1951_n5340 BUFX12 $PINS A=n5340 Y=FE_OFN5978_n5340
XFE_OFC1947_n5275 BUFX3 $PINS A=n5275 Y=FE_OFN5974_n5275
XFE_OFC1943_n5481 BUFX4 $PINS A=n5481 Y=FE_OFN5970_n5481
XFE_OFC1939_n4975 BUFX4 $PINS A=FE_OFN549_n4975 Y=FE_OFN5966_n
XFE_OFC1931_n5004 CLKBUFX8 $PINS A=n5004 Y=FE_OFN5958_n5004
XFE_OFC1930_n5634 BUFX3 $PINS A=n5634 Y=FE_OFN5957_n5634
XFE_OFC1929_n5349 BUFX4 $PINS A=n5349 Y=FE_OFN5956_n5349
XFE_OFC1926_n5323 CLKBUFX8 $PINS A=n5323 Y=FE_OFN5953_n5323
XFE_OFC1924_n4226 BUFX4 $PINS A=n4226 Y=FE_OFN5951_n4226
XFE_OFC1923_n4451 CLKBUFX8 $PINS A=FE_RN_29 Y=FE_OFN5950_n4451
XFE_OFC1921_FE_DBTN149_i_reset CLKBUFX8 $PINS A=FE_OFN5634_FE_DBTN149_i_reset
+ Y=FE_OFN5948_n
XFE_OFC1918_FE_DBTN149_i_reset BUFX4 $PINS A=FE_OFN5636_FE_DBTN149_i_reset
+ Y=FE_OFN5945_n
XFE_OFC1916_FE_DBTN149_i_reset BUFX3 $PINS A=FE_OFN5632_FE_DBTN149_i_reset
+ Y=FE_OFN5943_n
XFE_OFC1908_n5321 INVX1 $PINS A=n5321 Y=N1386
XFE_OFC1907_n5321 INVX1 $PINS A=n5321 Y=N1455
XFE_OFC1903_N612 BUFX3 $PINS A=FE_OFN5593_N612 Y=FE_OFN5936_N612
XFE_OFC1902_N612 INVX1 $PINS A=FE_OFN5593_N612 Y=FE_OFN354_N612
XFE_OFC1901_N612 BUFX3 $PINS A=N612 Y=FE_OFN5593_N612
XFE_OFC1899_n5107 CLKINVX3 $PINS A=n5108 Y=FE_OFN5934_n5107
XFE_OFC1898_n5107 CLKINVX3 $PINS A=n5107 Y=n5108
XFE_OFC1892_register_2__1 INVX4 $PINS A=FE_OFN5544_register_2__1
+ Y=FE_DBTN1181_register_2_1
XFE_OFC1891_register_2__1 CLKBUFX8 $PINS A=register[2][1]
+ Y=FE_OFN5544_register_2__1
XFE_OFC1890_register_5__8 INVX1 $PINS A=register[5][8]
+ Y=FE_OFN5932_register_5__8
XFE_OFC1885_register_8__19 INVX8 $PINS A=FE_OFN5582_register_8__19
+ Y=FE_DBTN1176_register_8_19
XFE_OFC1884_register_8__19 BUFX4 $PINS A=register[8][19]
+ Y=FE_OFN5582_register_8__19
XFE_OFC1883_n5502 INVX1 $PINS A=n5222 Y=FE_OFN5928_n5502
XFE_OFC1882_n5502 CLKINVX8 $PINS A=n5502 Y=n5222
XFE_OFC1873_N611 INVX4 $PINS A=FE_OFN5592_N611 Y=FE_OFN89_N611
XFE_OFC1872_N611 BUFX4 $PINS A=N611 Y=FE_OFN5592_N611
XFE_OFC1871_register_1__7 BUFX12 $PINS A=register[1][7]
+ Y=FE_OFN5526_register_1__7
XFE_OFC1870_register_1__9 CLKBUFX8 $PINS A=register[1][9]
+ Y=FE_OFN5524_register_1__9
XFE_OFC1866_N608 INVX1 $PINS A=FE_OFN5590_N608 Y=FE_OFN5920_N608
XFE_OFC1865_N608 INVX1 $PINS A=FE_OFN5590_N608 Y=FE_OFN5919_N608
XFE_OFC1864_N608 BUFX3 $PINS A=FE_OFN5590_N608 Y=FE_DBTN31_N608
XFE_OFC1863_N608 BUFX3 $PINS A=N608 Y=FE_OFN5590_N608
XFE_OFC1852_register_0__6 INVX2 $PINS A=register[0][6]
+ Y=FE_OFN5914_register_0__6
XFE_OFC1846_register_4__16 INVXL $PINS A=FE_OFN5551_register_4__16
+ Y=FE_OFN5910_register_4__16
XFE_OFC1845_register_4__16 INVX1 $PINS A=FE_OFN5551_register_4__16
+ Y=FE_OFN78_register_4__16
XFE_OFC1844_register_4__16 CLKINVX3 $PINS A=register[4][16]
+ Y=FE_OFN5551_register_4__16
XFE_OFC1842_n5475 CLKINVX3 $PINS A=n5475 Y=n5219
XFE_OFC1837_register_6__11 INVX8 $PINS A=FE_OFN5568_register_6__11
+ Y=FE_DBTN69_register_6_11
XFE_OFC1836_register_6__11 BUFX3 $PINS A=register[6][11]
+ Y=FE_OFN5568_register_6__11
XFE_OFC1835_register_4__8 CLKINVX3 $PINS A=FE_OFN5556_register_4__8
+ Y=FE_OFN5905_register_4__8
XFE_OFC1834_register_4__8 INVX1 $PINS A=FE_OFN5556_register_4__8
+ Y=FE_DBTN94_register_4_8
XFE_OFC1833_register_4__8 BUFX4 $PINS A=register[4][8]
+ Y=FE_OFN5556_register_4__8
XFE_OFC1831_register_2__12 CLKINVX3 $PINS A=FE_OFN5536_register_2__12
+ Y=FE_DBTN122_register_2_12
XFE_OFC1830_register_2__12 CLKBUFX8 $PINS A=register[2][12]
+ Y=FE_OFN5536_register_2__12
XFE_OFC1829_register_1__14 CLKBUFX8 $PINS A=register[1][14]
+ Y=FE_OFN5522_register_1__14
XFE_OFC1824_register_0__12 CLKINVX8 $PINS A=FE_OFN5518_register_0__12
+ Y=FE_OFN5901_register_0__12
XFE_OFC1819_register_0__12 CLKINVX3 $PINS A=register[0][12]
+ Y=FE_OFN5518_register_0__12
XFE_OFC1818_register_7__7 INVX1 $PINS A=n5643 Y=FE_OFN5897_register_7__7
XFE_OFC1817_register_7__7 CLKINVX3 $PINS A=n5643 Y=FE_OFN5896_register_7__7
XFE_OFC1816_register_7__7 CLKINVX3 $PINS A=register[7][7] Y=n5643
XFE_OFC1815_register_0__9 CLKINVX3 $PINS A=register[0][9]
+ Y=FE_OFN5895_register_0__9
XFE_OFC1808_register_1__13 CLKBUFX8 $PINS A=register[1][13]
+ Y=FE_OFN5523_register_1__13
XFE_OFC1800_register_6__5 CLKINVX4 $PINS A=FE_OFN5573_register_6__5
+ Y=FE_DBTN63_register_6_5
XFE_OFC1799_register_6__5 CLKINVX3 $PINS A=register[6][5]
+ Y=FE_OFN5573_register_6__5
XFE_OFC1798_N872 INVX1 $PINS A=FE_OFN5600_N872 Y=FE_DBTN1179_N872
XFE_OFC1795_N872 BUFX3 $PINS A=N872 Y=FE_OFN5600_N872
XFE_OFC1792_N567 INVX4 $PINS A=N15861 Y=FE_OFN5883_N567
XFE_OFC1791_N567 BUFX4 $PINS A=N567 Y=N15861
XFE_OFC1786_register_6__4 CLKINVX3 $PINS A=FE_OFN5574_register_6__4
+ Y=FE_DBTN62_register_6_4
XFE_OFC1785_register_6__4 INVX4 $PINS A=register[6][4]
+ Y=FE_OFN5574_register_6__4
XFE_OFC1784_n4756 INVX1 $PINS A=n4756 Y=n5690
XFE_OFC1783_register_3__15 INVX2 $PINS A=register[3][15]
+ Y=FE_OFN5878_register_3__15
XFE_OFC1781_register_0__7 CLKINVX3 $PINS A=FE_DBTN139_register_0_7
+ Y=FE_OFN5877_register_0__7
XFE_OFC1780_register_0__7 BUFX4 $PINS A=register[0][7]
+ Y=FE_DBTN139_register_0_7
XFE_OFC1775_register_4__10 CLKINVX3 $PINS A=FE_OFN5554_register_4__10
+ Y=FE_OFN5874_register_4__10
XFE_OFC1772_register_4__10 INVX1 $PINS A=FE_OFN5554_register_4__10
+ Y=FE_DBTN96_register_4_10
XFE_OFC1771_register_4__10 INVX4 $PINS A=register[4][10]
+ Y=FE_OFN5554_register_4__10
XFE_OFC1769_register_2__18 INVX4 $PINS A=FE_OFN5530_register_2__18
+ Y=FE_OFN5870_register_2__18
XFE_OFC1768_register_2__18 INVX1 $PINS A=FE_OFN5530_register_2__18
+ Y=FE_OFN312_register_2__18
XFE_OFC1765_register_2__18 CLKBUFX8 $PINS A=register[2][18]
+ Y=FE_OFN5530_register_2__18
XFE_OFC1762_register_4__11 INVX4 $PINS A=FE_OFN5553_register_4__11
+ Y=FE_OFN5865_register_4__11
XFE_OFC1760_register_4__11 INVX2 $PINS A=register[4][11]
+ Y=FE_OFN5553_register_4__11
XFE_OFC1758_register_0__17 INVX1 $PINS A=FE_OFN5517_register_0__17
+ Y=FE_OFN5863_register_0__17
XFE_OFC1757_register_0__17 BUFX3 $PINS A=FE_OFN5517_register_0__17
+ Y=FE_DBTN1170_register_0_17
XFE_OFC1756_register_0__17 BUFX3 $PINS A=register[0][17]
+ Y=FE_OFN5517_register_0__17
XFE_OFC1755_register_0__8 CLKINVX3 $PINS A=FE_DBTN140_register_0_8
+ Y=FE_OFN5862_register_0__8
XFE_OFC1754_register_0__8 BUFX3 $PINS A=register[0][8]
+ Y=FE_DBTN140_register_0_8
XFE_OFC1751_register_1__16 CLKBUFX8 $PINS A=register[1][16]
+ Y=FE_OFN5520_register_1__16
XFE_OFC1750_register_1__4 BUFX12 $PINS A=register[1][4]
+ Y=FE_OFN5527_register_1__4
XFE_OFC1745_register_6__3 INVX2 $PINS A=FE_OFN5575_register_6__3
+ Y=FE_DBTN1183_register_6_3
XFE_OFC1744_register_6__3 BUFX3 $PINS A=register[6][3]
+ Y=FE_OFN5575_register_6__3
XFE_OFC1742_n4910 INVX4 $PINS A=FE_OCPN6243_n5834 Y=FE_OFN5857_n4910
XFE_OFC1732_FE_DBTN21_N1711 INVX1 $PINS A=FE_OFN5852_FE_DBTN21_N1711
+ Y=FE_OFN5848_FE_DBTN21_N1711
XFE_OFC1729_register_0__18 CLKINVX3 $PINS A=FE_OFN5516_register_0__18
+ Y=FE_OFN5846_register_0__18
XFE_OFC1727_register_0__18 BUFX4 $PINS A=register[0][18]
+ Y=FE_OFN5516_register_0__18
XFE_OFC1725_n5104 CLKINVX4 $PINS A=n5104 Y=n5106
XFE_OFC1723_register_2__7 INVX4 $PINS A=FE_OFN5541_register_2__7
+ Y=FE_DBTN118_register_2_7
XFE_OFC1722_register_2__7 CLKBUFX8 $PINS A=register[2][7]
+ Y=FE_OFN5541_register_2__7
XFE_OFC1720_register_2__5 BUFX3 $PINS A=FE_OFN6038_register_2__5
+ Y=FE_OFN5842_register_2__5
XFE_OFC1719_register_2__5 INVX4 $PINS A=FE_OFN6038_register_2__5
+ Y=FE_DBTN116_register_2_5
XFE_OFC1715_register_4__9 BUFX3 $PINS A=FE_OFN5555_register_4__9
+ Y=FE_OFN5839_register_4__9
XFE_OFC1712_register_4__9 INVX4 $PINS A=FE_OFN5555_register_4__9
+ Y=FE_OFN335_register_4__9
XFE_OFC1711_register_4__9 INVX2 $PINS A=register[4][9]
+ Y=FE_OFN5555_register_4__9
XFE_OFC1704_N1281 BUFX3 $PINS A=N1281 Y=N1315
XFE_OFC1699_register_6__8 INVXL $PINS A=FE_OFN5570_register_6__8
+ Y=FE_OFN5830_register_6__8
XFE_OFC1697_register_6__8 CLKINVX3 $PINS A=register[6][8]
+ Y=FE_OFN5570_register_6__8
XFE_OFC1692_register_2__19 INVX4 $PINS A=FE_OFN5529_register_2__19
+ Y=FE_DBTN1175_register_2_19
XFE_OFC1691_register_2__19 BUFX4 $PINS A=register[2][19]
+ Y=FE_OFN5529_register_2__19
XFE_OFC1690_register_4__5 INVXL $PINS A=FE_OFN5826_register_4__5
+ Y=FE_OFN5827_register_4__5
XFE_OFC1689_register_4__5 INVX2 $PINS A=FE_DBTN91_register_4_5
+ Y=FE_OFN5826_register_4__5
XFE_OFC1688_register_4__5 BUFX4 $PINS A=register[4][5] Y=FE_DBTN91_register_4_5
XFE_OFC1686_register_4__12 CLKINVX3 $PINS A=FE_DBTN98_register_4_12
+ Y=FE_OFN5824_register_4__12
XFE_OFC1683_register_8__18 INVX1 $PINS A=FE_OFN5583_register_8__18
+ Y=FE_OFN5822_register_8__18
XFE_OFC1682_register_8__18 INVX1 $PINS A=FE_OFN5583_register_8__18
+ Y=FE_DBTN1161_register_8_18
XFE_OFC1680_register_8__18 BUFX3 $PINS A=register[8][18]
+ Y=FE_OFN5583_register_8__18
XFE_OFC1678_register_8__12 INVX1 $PINS A=FE_OFN605_register_8__12
+ Y=FE_OFN5819_register_8__12
XFE_OFC1677_register_8__12 INVX4 $PINS A=FE_OFN5585_register_8__12
+ Y=FE_OFN605_register_8__12
XFE_OFC1676_register_8__12 BUFX3 $PINS A=register[8][12]
+ Y=FE_OFN5585_register_8__12
XFE_OFC1673_register_1__15 CLKBUFX8 $PINS A=register[1][15]
+ Y=FE_OFN5521_register_1__15
XFE_OFC1672_register_2__11 INVX1 $PINS A=FE_OFN5537_register_2__11
+ Y=FE_OFN5818_register_2__11
XFE_OFC1671_register_2__11 INVX1 $PINS A=FE_OFN5537_register_2__11
+ Y=FE_DBTN121_register_2_11
XFE_OFC1669_register_2__11 BUFX4 $PINS A=register[2][11]
+ Y=FE_OFN5537_register_2__11
XFE_OFC1668_register_5__7 INVX1 $PINS A=FE_OFN5564_register_5__7
+ Y=FE_OFN5816_register_5__7
XFE_OFC1667_register_5__7 INVX1 $PINS A=FE_OFN5564_register_5__7
+ Y=FE_OFN400_register_5__7
XFE_OFC1666_register_5__7 BUFX4 $PINS A=register[5][7]
+ Y=FE_OFN5564_register_5__7
XFE_OFC1663_register_4__4 CLKINVX3 $PINS A=FE_DBTN90_register_4_4
+ Y=FE_OFN5814_register_4__4
XFE_OFC1662_register_4__4 INVX1 $PINS A=register[4][4] Y=FE_DBTN90_register_4_4
XFE_OFC1661_register_3__18 INVX1 $PINS A=FE_DBTN112_register_3_18
+ Y=FE_OFN5813_register_3__18
XFE_OFC1660_register_3__18 CLKINVX3 $PINS A=register[3][18]
+ Y=FE_DBTN112_register_3_18
XFE_OFC1659_register_3__18 BUFX3 $PINS A=register[3][18]
+ Y=FE_OFN5545_register_3__18
XFE_OFC1650_n5280 INVX8 $PINS A=n5280 Y=n4887
XFE_OFC1649_n4337 INVX1 $PINS A=n6623 Y=FE_OFN5807_n4337
XFE_OFC1648_n4337 INVX1 $PINS A=n4337 Y=n6623
XFE_OFC1646_register_6__6 INVX2 $PINS A=FE_OFN5572_register_6__6
+ Y=FE_DBTN64_register_6_6
XFE_OFC1645_register_6__6 BUFX3 $PINS A=register[6][6]
+ Y=FE_OFN5572_register_6__6
XFE_OFC1644_register_2__17 INVX1 $PINS A=FE_OFN5531_register_2__17
+ Y=FE_OFN5805_register_2__17
XFE_OFC1643_register_2__17 CLKINVX3 $PINS A=FE_OFN5531_register_2__17
+ Y=FE_DBTN127_register_2_17
XFE_OFC1642_register_2__17 BUFX4 $PINS A=register[2][17]
+ Y=FE_OFN5531_register_2__17
XFE_OFC1641_N1316 INVX4 $PINS A=N1282 Y=FE_OFN5804_N1316
XFE_OFC1640_N1316 INVX8 $PINS A=N1316 Y=N1282
XFE_OFC1631_register_7__16 INVX1 $PINS A=FE_OFN5577_register_7__16 Y=n5649
XFE_OFC1630_register_7__16 INVX1 $PINS A=register[7][16]
+ Y=FE_OFN5577_register_7__16
XFE_OFC1628_register_6__7 CLKINVX3 $PINS A=FE_OFN5571_register_6__7
+ Y=FE_OFN390_register_6__7
XFE_OFC1627_register_6__7 BUFX4 $PINS A=register[6][7]
+ Y=FE_OFN5571_register_6__7
XFE_OFC1625_n4440 INVX1 $PINS A=n5566 Y=FE_OFN5796_n4440
XFE_OFC1623_n4440 INVX1 $PINS A=n4440 Y=n5566
XFE_OFC1621_register_8__9 CLKINVX3 $PINS A=FE_OFN5586_register_8__9
+ Y=FE_OFN5793_register_8__9
XFE_OFC1618_register_8__9 INVXL $PINS A=FE_OFN5586_register_8__9
+ Y=FE_OFN297_register_8__9
XFE_OFC1617_register_8__9 INVX4 $PINS A=register[8][9]
+ Y=FE_OFN5586_register_8__9
XFE_OFC1616_register_0__13 INVX2 $PINS A=register[0][13]
+ Y=FE_OFN5790_register_0__13
XFE_OFC1614_register_2__6 INVX4 $PINS A=FE_OFN5787_register_2__6
+ Y=FE_OFN5789_register_2__6
XFE_OFC1613_register_2__6 INVX1 $PINS A=FE_OFN5787_register_2__6
+ Y=FE_OFN5788_register_2__6
XFE_OFC1612_register_2__6 INVX4 $PINS A=FE_OFN5542_register_2__6
+ Y=FE_OFN5787_register_2__6
XFE_OFC1609_register_2__6 INVX2 $PINS A=register[2][6]
+ Y=FE_OFN5542_register_2__6
XFE_OFC1606_register_7__9 INVX1 $PINS A=FE_DBTN54_register_7_9
+ Y=FE_OFN5783_register_7__9
XFE_OFC1605_register_7__9 CLKINVX4 $PINS A=register[7][9]
+ Y=FE_DBTN54_register_7_9
XFE_OFC1603_register_2__10 INVX2 $PINS A=FE_OFN5538_register_2__10
+ Y=FE_OFN5781_register_2__10
XFE_OFC1602_register_2__10 INVX1 $PINS A=FE_OFN5538_register_2__10
+ Y=FE_OFN370_register_2__10
XFE_OFC1601_register_2__10 CLKBUFX8 $PINS A=register[2][10]
+ Y=FE_OFN5538_register_2__10
XFE_OFC1594_register_7__8 CLKINVX3 $PINS A=register[7][8] Y=n5644
XFE_OFC1593_register_2__14 BUFX3 $PINS A=FE_DBTN1156_register_2_14
+ Y=FE_OFN5779_register_2__14
XFE_OFC1592_register_2__14 CLKINVX3 $PINS A=FE_DBTN1156_register_2_14
+ Y=FE_OFN5534_register_2__14
XFE_OFC1591_register_2__14 BUFX3 $PINS A=register[2][14]
+ Y=FE_DBTN1156_register_2_14
XFE_OFC1590_register_7__6 CLKINVX3 $PINS A=register[7][6] Y=n5642
XFE_OFC1588_register_8__2 CLKINVX3 $PINS A=FE_DBTN34_register_8_2
+ Y=FE_OFN5777_register_8__2
XFE_OFC1587_register_8__2 CLKINVX3 $PINS A=register[8][2]
+ Y=FE_DBTN34_register_8_2
XFE_OFC1585_n5319 CLKINVX8 $PINS A=FE_DBTN10_N1176 Y=FE_OFN5775_n5319
XFE_OFC1583_n5319 CLKINVX3 $PINS A=n5319 Y=FE_DBTN10_N1176
XFE_OFC1581_register_4__6 CLKINVX3 $PINS A=register[4][6]
+ Y=FE_DBTN1174_register_4_6
XFE_OFC1578_register_8__7 CLKINVX3 $PINS A=FE_DBTN39_register_8_7
+ Y=FE_OFN5771_register_8__7
XFE_OFC1575_register_8__7 INVX8 $PINS A=FE_OFN6026_register_8__7
+ Y=FE_DBTN39_register_8_7
XFE_OFC1574_register_2__4 INVX1 $PINS A=FE_OFN5543_register_2__4
+ Y=FE_OFN5767_register_2__4
XFE_OFC1572_register_2__4 INVX1 $PINS A=FE_OFN5543_register_2__4
+ Y=FE_DBTN1155_register_2_4
XFE_OFC1571_register_2__4 CLKBUFX8 $PINS A=register[2][4]
+ Y=FE_OFN5543_register_2__4
XFE_OFC1570_register_3__14 BUFX3 $PINS A=FE_OFN5547_register_3__14
+ Y=FE_OFN5766_register_3__14
XFE_OFC1569_register_3__14 INVX1 $PINS A=FE_OFN5547_register_3__14
+ Y=FE_OFN5765_register_3__14
XFE_OFC1567_register_3__14 CLKINVX3 $PINS A=register[3][14]
+ Y=FE_OFN5547_register_3__14
XFE_OFC1563_register_0__3 INVX4 $PINS A=FE_DBTN137_register_0_3
+ Y=FE_OFN5761_register_0__3
XFE_OFC1562_register_0__3 INVX8 $PINS A=register[0][3]
+ Y=FE_DBTN137_register_0_3
XFE_OFC1560_FE_RN_74_0 INVX1 $PINS A=FE_OFN5760_FE_RN_74_0
+ Y=FE_OFN5759_FE_RN_74_0
XFE_OFC1557_register_6__18 CLKINVX3 $PINS A=FE_OFN5567_register_6__18
+ Y=FE_OFN5757_register_6__18
XFE_OFC1556_register_6__18 INVX1 $PINS A=FE_OFN5567_register_6__18
+ Y=FE_DBTN76_register_6_18
XFE_OFC1555_register_6__18 INVX4 $PINS A=register[6][18]
+ Y=FE_OFN5567_register_6__18
XFE_OFC1554_register_0__14 INVX4 $PINS A=FE_OFN6049_register_0__14
+ Y=FE_DBTN145_register_0_14
XFE_OFC1551_register_2__8 BUFX3 $PINS A=FE_OFN5540_register_2__8
+ Y=FE_OFN5755_register_2__8
XFE_OFC1549_register_2__8 CLKINVX4 $PINS A=FE_OFN5540_register_2__8
+ Y=FE_OFN5753_register_2__8
XFE_OFC1547_register_2__8 INVX1 $PINS A=FE_OFN5540_register_2__8
+ Y=FE_OFN5751_register_2__8
XFE_OFC1546_register_2__8 INVXL $PINS A=FE_OFN5540_register_2__8
+ Y=FE_OFN5750_register_2__8
XFE_OFC1545_register_2__8 INVXL $PINS A=FE_OFN5540_register_2__8
+ Y=FE_DBTN1159_register_2_8
XFE_OFC1544_register_2__8 INVX4 $PINS A=register[2][8]
+ Y=FE_OFN5540_register_2__8
XFE_OFC1542_register_4__13 INVX1 $PINS A=FE_OFN309_register_4__13
+ Y=FE_OFN5748_register_4__13
XFE_OFC1541_register_4__13 CLKINVX3 $PINS A=register[4][13]
+ Y=FE_OFN309_register_4__13
XFE_OFC1540_N609 INVX1 $PINS A=FE_DBTN30_N609 Y=FE_OFN5747_N609
XFE_OFC1539_N609 INVX1 $PINS A=N609 Y=FE_DBTN30_N609
XFE_OFC1537_register_4__14 INVX1 $PINS A=FE_OFN79_register_4__14
+ Y=FE_OFN5745_register_4__14
XFE_OFC1536_register_4__14 CLKINVX3 $PINS A=FE_OFN5552_register_4__14
+ Y=FE_OFN79_register_4__14
XFE_OFC1535_register_4__14 BUFX3 $PINS A=register[4][14]
+ Y=FE_OFN5552_register_4__14
XFE_OFC1533_n4963 CLKINVX3 $PINS A=n4963 Y=FE_DBTN1158_n4963
XFE_OFC1532_register_6__9 INVX4 $PINS A=FE_OFN5569_register_6__9
+ Y=FE_OFN616_register_6__9
XFE_OFC1531_register_6__9 BUFX3 $PINS A=register[6][9]
+ Y=FE_OFN5569_register_6__9
XFE_OFC1530_register_7__3 INVX4 $PINS A=register[7][3] Y=FE_DBTN53_register_7_3
XFE_OFC1529_N1177 CLKINVX3 $PINS A=FE_OFN6039_N1177 Y=FE_DBTN11_N1177
XFE_OFC1528_register_5__3 CLKINVX8 $PINS A=FE_DBTN78_register_5_3
+ Y=FE_OFN5743_register_5__3
XFE_OFC1527_register_5__3 INVX4 $PINS A=register[5][3] Y=FE_DBTN78_register_5_3
XFE_OFC1526_register_8__11 INVX2 $PINS A=FE_OFN6036_register_8__11
+ Y=FE_OFN5742_register_8__11
XFE_OFC1525_register_8__11 INVX1 $PINS A=FE_OFN6036_register_8__11
+ Y=FE_DBTN43_register_8_11
XFE_OFC1523_register_4__19 INVXL $PINS A=FE_OFN5550_register_4__19
+ Y=FE_OFN5740_register_4__19
XFE_OFC1521_register_4__19 INVX1 $PINS A=FE_OFN5550_register_4__19
+ Y=FE_DBTN1177_register_4_19
XFE_OFC1520_register_4__19 CLKINVX3 $PINS A=register[4][19]
+ Y=FE_OFN5550_register_4__19
XFE_OFC1518_register_6__12 CLKINVX3 $PINS A=register[6][12]
+ Y=FE_DBTN70_register_6_12
XFE_OFC1514_register_0__19 INVX1 $PINS A=register[0][19]
+ Y=FE_OFN5735_register_0__19
XFE_OFC1513_register_0__19 BUFX3 $PINS A=register[0][19]
+ Y=FE_DBTN1167_register_0_19
XFE_OFC1510_register_8__8 BUFX3 $PINS A=FE_DBTN1165_register_8_8
+ Y=FE_OFN5732_register_8__8
XFE_OFC1509_register_8__8 CLKINVX3 $PINS A=FE_DBTN1165_register_8_8
+ Y=FE_OFN5731_register_8__8
XFE_OFC1507_register_8__8 INVX4 $PINS A=register[8][8]
+ Y=FE_DBTN1165_register_8_8
XFE_OFC1506_N999 CLKINVX3 $PINS A=FE_DBTN8_N1034 Y=FE_OFN5730_N999
XFE_OFC1504_N999 INVX1 $PINS A=FE_DBTN8_N1034 Y=FE_OFN5728_N999
XFE_OFC1502_N999 CLKINVX4 $PINS A=FE_OFN6005_N999 Y=FE_DBTN8_N1034
XFE_OFC1501_register_4__7 CLKINVX3 $PINS A=register[4][7]
+ Y=FE_DBTN1173_register_4_7
XFE_OFC1499_register_0__16 CLKINVX3 $PINS A=register[0][16]
+ Y=FE_DBTN146_register_0_16
XFE_OFC1494_i_cdata_rd_6 CLKINVX3 $PINS A=cdata_rd[6] Y=n5077
XFE_OFC1492_register_6__19 CLKINVX3 $PINS A=register[6][19]
+ Y=FE_DBTN77_register_6_19
XFE_OFC1489_register_5__2 INVX4 $PINS A=n5537 Y=FE_OFN5722_register_5__2
XFE_OFC1488_register_5__2 CLKINVX3 $PINS A=register[5][2] Y=n5537
XFE_OFC1487_register_5__4 CLKINVX4 $PINS A=n5534 Y=FE_OFN5721_register_5__4
XFE_OFC1486_register_5__4 CLKINVX3 $PINS A=register[5][4] Y=n5534
XFE_OFC1484_register_3__12 INVX2 $PINS A=register[3][12]
+ Y=FE_DBTN1171_register_3_12
XFE_OFC1483_register_8__5 INVX4 $PINS A=FE_DBTN1163_register_8_5
+ Y=FE_OFN5719_register_8__5
XFE_OFC1482_register_8__5 CLKBUFX8 $PINS A=register[8][5]
+ Y=FE_DBTN1163_register_8_5
XFE_OFC1481_N1695 INVXL $PINS A=N1695 Y=n5820
XFE_OFC1479_register_8__13 CLKINVX3 $PINS A=FE_DBTN45_register_8_13
+ Y=FE_OFN5717_register_8__13
XFE_OFC1476_register_8__13 CLKINVX3 $PINS A=register[8][13]
+ Y=FE_DBTN45_register_8_13
XFE_OFC1474_register_8__16 INVX1 $PINS A=FE_OFN5979_register_8__16
+ Y=FE_OFN5713_register_8__16
XFE_OFC1473_register_8__16 CLKINVX3 $PINS A=FE_OFN5979_register_8__16
+ Y=FE_OFN306_register_8__16
XFE_OFC1472_register_4__15 INVX1 $PINS A=register[4][15]
+ Y=FE_OFN5712_register_4__15
XFE_OFC1471_register_4__15 INVX1 $PINS A=register[4][15]
+ Y=FE_OFN5711_register_4__15
XFE_OFC1468_register_8__15 INVX1 $PINS A=FE_OFN5993_register_8__15
+ Y=FE_OFN5709_register_8__15
XFE_OFC1467_register_8__15 INVX1 $PINS A=FE_OFN5993_register_8__15
+ Y=FE_DBTN1166_register_8_15
XFE_OFC1464_register_3__17 INVX2 $PINS A=register[3][17]
+ Y=FE_OFN5707_register_3__17
XFE_OFC1460_register_8__3 INVX4 $PINS A=FE_OFN6011_register_8__3
+ Y=FE_DBTN1169_register_8_3
XFE_OFC1455_register_4__18 CLKINVX3 $PINS A=FE_DBTN103_register_4_18
+ Y=FE_OFN5703_register_4__18
XFE_OFC1452_register_4__18 BUFX3 $PINS A=register[4][18]
+ Y=FE_DBTN103_register_4_18
XFE_OFC1451_register_7__18 INVX1 $PINS A=register[7][18]
+ Y=FE_OFN5700_register_7__18
XFE_OFC1449_register_8__4 INVX4 $PINS A=FE_OFN6018_register_8__4
+ Y=FE_DBTN1164_register_8_4
XFE_OFC1448_register_6__10 INVX1 $PINS A=register[6][10]
+ Y=FE_DBTN68_register_6_10
XFE_OFC1445_register_3__19 INVX2 $PINS A=register[3][19]
+ Y=FE_DBTN1162_register_3_19
XFE_OFC1440_register_6__17 CLKINVX3 $PINS A=register[6][17]
+ Y=FE_DBTN75_register_6_17
XFE_OFC1437_register_6__16 INVX1 $PINS A=register[6][16]
+ Y=FE_DBTN74_register_6_16
XFE_OFC1432_register_8__17 CLKINVX3 $PINS A=FE_DBTN49_register_8_17
+ Y=FE_OFN5691_register_8__17
XFE_OFC1430_register_8__17 CLKINVX3 $PINS A=register[8][17]
+ Y=FE_DBTN49_register_8_17
XFE_OFC1429_n4374 INVX1 $PINS A=n4374 Y=n6645
XFE_OFC1428_register_6__13 CLKINVX3 $PINS A=FE_OFN5989_register_6__13
+ Y=FE_DBTN71_register_6_13
XFE_OFC1427_register_7__2 CLKINVX3 $PINS A=register[7][2]
+ Y=FE_OFN5689_register_7__2
XFE_OFC1425_FE_RN_5 BUFX3 $PINS A=FE_OCPN6241_FE_OFN6056_FE_RN_5
+ Y=FE_OFN5688_FE_RN_5
XFE_OFC1423_FE_RN_5 INVX1 $PINS A=FE_OCPN6242_FE_OFN6056_FE_RN_5
+ Y=FE_OFN5686_FE_RN_5
XFE_OFC1422_FE_RN_5 INVXL $PINS A=FE_OFN6056_FE_RN_5 Y=FE_OFN5685_FE_RN_5
XFE_OFC1417_register_6__14 CLKINVX3 $PINS A=register[6][14]
+ Y=FE_DBTN72_register_6_14
XFE_OFC1412_register_6__15 CLKINVX3 $PINS A=FE_OFN5984_register_6__15
+ Y=FE_DBTN73_register_6_15
XFE_OFC1409_n5350 CLKINVX3 $PINS A=FE_OFN5677_n5350 Y=FE_OFN5678_n5350
XFE_OFC1408_n5350 CLKINVX8 $PINS A=n5350 Y=FE_OFN5677_n5350
XFE_OFC1407_n5350 BUFX3 $PINS A=n5350 Y=n5925
XFE_OFC1402_i_idata_7 INVX1 $PINS A=n5035 Y=FE_OFN5674_i_idata_7
XFE_OFC1401_i_idata_7 CLKINVX3 $PINS A=idata[7] Y=n5035
XFE_OFC1390_N1618 INVX4 $PINS A=FE_DBTN1180_N1618 Y=FE_OFN5668_N1618
XFE_OFC1389_N1618 BUFX12 $PINS A=N1618 Y=FE_DBTN1180_N1618
XFE_OFC1388_n4546 INVX1 $PINS A=n6636 Y=FE_OFN5667_n4546
XFE_OFC1387_n4546 INVX1 $PINS A=n4546 Y=n6636
XFE_OFC1386_register_8__10 CLKINVX3 $PINS A=FE_DBTN1172_register_8_10
+ Y=FE_OFN5666_register_8__10
XFE_OFC1384_register_8__10 CLKINVX4 $PINS A=register[8][10]
+ Y=FE_DBTN1172_register_8_10
XFE_OFC1381_n4999 BUFX3 $PINS A=FE_OFN5662_n4999 Y=FE_OFN5663_n4999
XFE_OFC1378_register_7__10 CLKINVX3 $PINS A=FE_OFN262_register_7__10
+ Y=FE_OFN5661_register_7__10
XFE_OFC1377_register_7__10 BUFX3 $PINS A=register[7][10]
+ Y=FE_OFN262_register_7__10
XFE_OFC1376_i_cdata_rd_0 CLKINVX3 $PINS A=cdata_rd[0] Y=n5073
XFE_OFC1370_n5505 BUFX4 $PINS A=FE_OCPN6250_n5505 Y=n5435
XFE_OFC1369_n4519 INVX1 $PINS A=n6622 Y=FE_OFN5657_n4519
XFE_OFC1368_n4519 INVX1 $PINS A=n4519 Y=n6622
XFE_OFC1365_n6755 CLKBUFX8 $PINS A=n5347 Y=FE_OFN5655_n6755
XFE_OFC1364_n6755 INVX4 $PINS A=n6755 Y=n5347
XFE_OFC1360_n4656 INVX20 $PINS A=n4656 Y=FE_OFN5653_n4656
XFE_OFC1359_n4656 CLKINVX2 $PINS A=n4656 Y=FE_DBTN1154_n4656
XFE_OFC1356_n4638 INVX1 $PINS A=n6644 Y=FE_OFN5651_n4638
XFE_OFC1355_n4638 INVX1 $PINS A=n4638 Y=n6644
XFE_OFC1352_n4407 CLKINVX3 $PINS A=FE_RN_31 Y=FE_OFN5649_n4407
XFE_OFC1351_n4407 INVX4 $PINS A=n4407 Y=FE_RN_31
XFE_OFC1348_n5323 BUFX3 $PINS A=FE_OFN5953_n5323 Y=FE_OFN5648_n5323
XFE_OFC1347_n5323 INVX8 $PINS A=FE_OFN5953_n5323 Y=N1424
XFE_OFC1344_n5531 CLKINVX3 $PINS A=FE_OFN5646_n5531 Y=FE_OFN5645_n5531
XFE_OFC1338_n5275 INVX1 $PINS A=n5275 Y=n5125
XFE_OFC1337_n4449 INVX1 $PINS A=n4449 Y=n4909
XFE_OFC1334_FE_RN_194_0 BUFX3 $PINS A=FE_OCPN2278_FE_OFN5639_FE_RN_194_0
+ Y=FE_OFN5641_FE_RN_194_0
XFE_OFC1331_FE_RN_194_0 INVX1 $PINS A=FE_OCPN2278_FE_OFN5639_FE_RN_194_0
+ Y=FE_OFN5638_FE_RN_194_0
XFE_OFC1329_FE_DBTN149_i_reset CLKINVX4 $PINS A=FE_OFN5635_FE_DBTN149_i_reset
+ Y=FE_OFN5637_FE_DBTN149_i_reset
XFE_OFC1328_FE_DBTN149_i_reset INVX1 $PINS A=FE_OFN5635_FE_DBTN149_i_reset
+ Y=FE_OFN5636_FE_DBTN149_i_reset
XFE_OFC1327_FE_DBTN149_i_reset INVX1 $PINS A=FE_OFN5633_FE_DBTN149_i_reset
+ Y=FE_OFN5635_FE_DBTN149_i_reset
XFE_OFC1326_FE_DBTN149_i_reset BUFX3 $PINS A=FE_OFN5633_FE_DBTN149_i_reset
+ Y=FE_OFN5634_FE_DBTN149_i_reset
XFE_OFC1325_FE_DBTN149_i_reset BUFX16 $PINS A=FE_OFN5632_FE_DBTN149_i_reset
+ Y=FE_OFN5633_FE_DBTN149_i_reset
XFE_OFC1324_FE_DBTN149_i_reset BUFX3 $PINS A=FE_DBTN149_i_reset
+ Y=FE_OFN5632_FE_DBTN149_i_reset
XFE_OFC1323_CMF1_0 BUFX3 $PINS A=CMF1[0] Y=FE_OFN5631_CMF1_0
XFE_OFC1322_CMF1_2 BUFX3 $PINS A=CMF1[2] Y=FE_OFN5630_CMF1_2
XFE_OFC1314_CMF0_2 BUFX3 $PINS A=CMF0[2] Y=FE_OFN5622_CMF0_2
XFE_OFC1313_CMF0_3 BUFX3 $PINS A=CMF0[3] Y=FE_OFN5621_CMF0_3
XFE_OFC1312_CMF0_5 BUFX3 $PINS A=CMF0[5] Y=FE_OFN5620_CMF0_5
XFE_OFC1309_CMF0_9 BUFX3 $PINS A=CMF0[9] Y=FE_OFN5617_CMF0_9
XFE_OFC1308_CMF0_10 BUFX3 $PINS A=CMF0[10] Y=FE_OFN5616_CMF0_10
XFE_OFC1307_CMF0_11 BUFX3 $PINS A=CMF0[11] Y=FE_OFN5615_CMF0_11
XFE_OFC1306_CMF0_12 BUFX3 $PINS A=CMF0[12] Y=FE_OFN5614_CMF0_12
XFE_OFC1305_CMF0_13 BUFX3 $PINS A=CMF0[13] Y=FE_OFN5613_CMF0_13
XFE_OFC1304_CMF0_14 BUFX3 $PINS A=CMF0[14] Y=FE_OFN5612_CMF0_14
XFE_OFC1303_CMF0_15 BUFX3 $PINS A=CMF0[15] Y=FE_OFN5611_CMF0_15
XFE_OFC1301_a_cnt_6 BUFX3 $PINS A=a_cnt[6] Y=FE_OFN5609_a_cnt_6
XFE_OFC1300_a_cnt_7 BUFX3 $PINS A=a_cnt[7] Y=FE_OFN5608_a_cnt_7
XFE_OFC1299_a_cnt_8 BUFX3 $PINS A=a_cnt[8] Y=FE_OFN5607_a_cnt_8
XFE_OFC1298_a_cnt_9 BUFX3 $PINS A=a_cnt[9] Y=FE_OFN5606_a_cnt_9
XFE_OFC1297_a_cnt_10 BUFX3 $PINS A=a_cnt[10] Y=FE_OFN5605_a_cnt_10
XFE_OFC1296_a_cnt_11 BUFX3 $PINS A=a_cnt[11] Y=FE_OFN5604_a_cnt_11
XFE_OFC1295_n5235 BUFX3 $PINS A=n5235 Y=FE_OFN5603_n5235
XFE_OFC1294_n4937 BUFX3 $PINS A=n4937 Y=FE_OFN5602_n4937
XFE_OFC1293_N1253 BUFX4 $PINS A=N1253 Y=FE_OFN5601_N1253
XFE_OFC1291_N8549 BUFX3 $PINS A=N8549 Y=FE_OFN5599_N8549
XFE_OFC1290_N8548 BUFX3 $PINS A=N8548 Y=FE_OFN5598_N8548
XFE_OFC1289_N8547 BUFX3 $PINS A=N8547 Y=FE_OFN5597_N8547
XFE_OFC1288_N8546 BUFX3 $PINS A=N8546 Y=FE_OFN5596_N8546
XFE_OFC1286_N8543 BUFX3 $PINS A=N8543 Y=FE_OFN5594_N8543
XFE_OFC1283_N610 BUFX3 $PINS A=N610 Y=FE_OFN5591_N610
XFE_OFC1280_N606 CLKBUFX8 $PINS A=N606 Y=FE_OFN5588_N606
XFE_OFC1279_register_8__6 CLKBUFX8 $PINS A=register[8][6]
+ Y=FE_OFN5587_register_8__6
XFE_OFC1276_register_8__14 BUFX3 $PINS A=register[8][14]
+ Y=FE_OFN5584_register_8__14
XFE_OFC1273_register_7__5 BUFX3 $PINS A=register[7][5]
+ Y=FE_OFN5581_register_7__5
XFE_OFC1272_register_7__12 BUFX3 $PINS A=register[7][12]
+ Y=FE_OFN5580_register_7__12
XFE_OFC1271_register_7__13 BUFX3 $PINS A=register[7][13]
+ Y=FE_OFN5579_register_7__13
XFE_OFC1270_register_7__14 BUFX3 $PINS A=register[7][14]
+ Y=FE_OFN5578_register_7__14
XFE_OFC1268_register_7__19 BUFX3 $PINS A=register[7][19]
+ Y=FE_OFN5576_register_7__19
XFE_OFC1257_register_5__6 CLKBUFX8 $PINS A=register[5][6]
+ Y=FE_OFN5565_register_5__6
XFE_OFC1255_register_5__9 CLKBUFX8 $PINS A=register[5][9]
+ Y=FE_OFN5563_register_5__9
XFE_OFC1254_register_5__10 CLKBUFX8 $PINS A=register[5][10]
+ Y=FE_OFN5562_register_5__10
XFE_OFC1253_register_5__12 CLKBUFX8 $PINS A=register[5][12]
+ Y=FE_OFN5561_register_5__12
XFE_OFC1252_register_5__15 BUFX3 $PINS A=register[5][15]
+ Y=FE_OFN5560_register_5__15
XFE_OFC1251_register_5__16 BUFX3 $PINS A=register[5][16]
+ Y=FE_OFN5559_register_5__16
XFE_OFC1250_register_5__19 BUFX3 $PINS A=register[5][19]
+ Y=FE_OFN5558_register_5__19
XFE_OFC1249_register_4__2 BUFX3 $PINS A=register[4][2]
+ Y=FE_OFN5557_register_4__2
XFE_OFC1241_register_3__10 BUFX4 $PINS A=register[3][10]
+ Y=FE_OFN5549_register_3__10
XFE_OFC1240_register_3__11 BUFX4 $PINS A=register[3][11]
+ Y=FE_OFN5548_register_3__11
XFE_OFC1238_register_3__16 BUFX4 $PINS A=register[3][16]
+ Y=FE_OFN5546_register_3__16
XFE_OFC1227_register_2__13 BUFX4 $PINS A=register[2][13]
+ Y=FE_OFN5535_register_2__13
XFE_OFC1225_register_2__15 CLKBUFX8 $PINS A=register[2][15]
+ Y=FE_OFN5533_register_2__15
XFE_OFC1224_register_2__16 CLKBUFX8 $PINS A=register[2][16]
+ Y=FE_OFN5532_register_2__16
XFE_OFC1220_register_1__3 CLKBUFX8 $PINS A=register[1][3]
+ Y=FE_OFN5528_register_1__3
XFE_OFC1217_register_1__8 CLKBUFX8 $PINS A=register[1][8]
+ Y=FE_OFN5525_register_1__8
XFE_OFC1211_register_1__19 BUFX12 $PINS A=register[1][19]
+ Y=FE_OFN5519_register_1__19
XFE_OFC1207_i_SCAN_EN BUFX3 $PINS A=FE_OFN5513_i_SCAN_EN Y=FE_OFN5515_i_SCAN_EN
XFE_OFC1206_i_SCAN_EN CLKINVX2 $PINS A=FE_OFN5511_i_SCAN_EN
+ Y=FE_OFN5514_i_SCAN_EN
XFE_OFC1205_i_SCAN_EN CLKINVX2 $PINS A=FE_OFN5511_i_SCAN_EN
+ Y=FE_OFN5513_i_SCAN_EN
XFE_OFC1204_i_SCAN_EN BUFX3 $PINS A=FE_OFN5510_i_SCAN_EN Y=FE_OFN5512_i_SCAN_EN
XFE_OFC1203_i_SCAN_EN INVX1 $PINS A=FE_OFN5509_i_SCAN_EN Y=FE_OFN5511_i_SCAN_EN
XFE_OFC1202_i_SCAN_EN BUFX3 $PINS A=FE_OFN5509_i_SCAN_EN Y=FE_OFN5510_i_SCAN_EN
XFE_OFC1201_i_SCAN_EN BUFX3 $PINS A=SCAN_EN Y=FE_OFN5509_i_SCAN_EN
XFE_OFC1200_i_csel_0 BUFX3 $PINS A=FE_OFN5508_i_csel_0 Y=csel[0]
XFE_OFC1199_i_csel_1 BUFX3 $PINS A=FE_OFN5507_i_csel_1 Y=csel[1]
XFE_OFC1198_i_csel_2 BUFX3 $PINS A=FE_OFN5506_i_csel_2 Y=csel[2]
XFE_OFC1197_i_caddr_rd_0 BUFX3 $PINS A=FE_OFN5505_i_caddr_rd_0 Y=caddr_rd[0]
XFE_OFC1196_i_caddr_rd_1 BUFX3 $PINS A=FE_OFN5504_i_caddr_rd_1 Y=caddr_rd[1]
XFE_OFC1195_i_caddr_rd_2 BUFX3 $PINS A=FE_OFN5503_i_caddr_rd_2 Y=caddr_rd[2]
XFE_OFC1194_i_caddr_rd_3 BUFX3 $PINS A=FE_OFN5502_i_caddr_rd_3 Y=caddr_rd[3]
XFE_OFC1193_i_caddr_rd_4 BUFX3 $PINS A=FE_OFN5501_i_caddr_rd_4 Y=caddr_rd[4]
XFE_OFC1192_i_caddr_rd_5 BUFX3 $PINS A=FE_OFN5500_i_caddr_rd_5 Y=caddr_rd[5]
XFE_OFC1191_i_caddr_rd_6 BUFX3 $PINS A=FE_OFN5499_i_caddr_rd_6 Y=caddr_rd[6]
XFE_OFC1190_i_caddr_rd_7 BUFX3 $PINS A=FE_OFN5498_i_caddr_rd_7 Y=caddr_rd[7]
XFE_OFC1189_i_caddr_rd_8 BUFX3 $PINS A=FE_OFN5497_i_caddr_rd_8 Y=caddr_rd[8]
XFE_OFC1188_i_caddr_rd_9 BUFX3 $PINS A=FE_OFN5496_i_caddr_rd_9 Y=caddr_rd[9]
XFE_OFC1187_i_caddr_rd_10 BUFX3 $PINS A=FE_OFN5495_i_caddr_rd_10 Y=caddr_rd[10]
XFE_OFC1186_i_caddr_rd_11 BUFX3 $PINS A=FE_OFN5494_i_caddr_rd_11 Y=caddr_rd[11]
XFE_OFC1185_i_crd BUFX3 $PINS A=FE_OFN5493_i_crd Y=crd
XFE_OFC1184_i_cdata_wr_0 BUFX3 $PINS A=FE_OFN5492_i_cdata_wr_0 Y=cdata_wr[0]
XFE_OFC1183_i_cdata_wr_1 BUFX3 $PINS A=FE_OFN5491_i_cdata_wr_1 Y=cdata_wr[1]
XFE_OFC1182_i_cdata_wr_2 BUFX3 $PINS A=FE_OFN5490_i_cdata_wr_2 Y=cdata_wr[2]
XFE_OFC1181_i_cdata_wr_3 BUFX3 $PINS A=FE_OFN5489_i_cdata_wr_3 Y=cdata_wr[3]
XFE_OFC1180_i_cdata_wr_4 BUFX3 $PINS A=FE_OFN5488_i_cdata_wr_4 Y=cdata_wr[4]
XFE_OFC1179_i_cdata_wr_5 BUFX3 $PINS A=FE_OFN5487_i_cdata_wr_5 Y=cdata_wr[5]
XFE_OFC1178_i_cdata_wr_6 BUFX3 $PINS A=FE_OFN5486_i_cdata_wr_6 Y=cdata_wr[6]
XFE_OFC1177_i_cdata_wr_7 BUFX3 $PINS A=FE_OFN5485_i_cdata_wr_7 Y=cdata_wr[7]
XFE_OFC1176_i_cdata_wr_8 BUFX3 $PINS A=FE_OFN5484_i_cdata_wr_8 Y=cdata_wr[8]
XFE_OFC1175_i_cdata_wr_9 BUFX3 $PINS A=FE_OFN5483_i_cdata_wr_9 Y=cdata_wr[9]
XFE_OFC1174_i_cdata_wr_10 BUFX3 $PINS A=FE_OFN5482_i_cdata_wr_10 Y=cdata_wr[10]
XFE_OFC1173_i_cdata_wr_11 BUFX3 $PINS A=FE_OFN5481_i_cdata_wr_11 Y=cdata_wr[11]
XFE_OFC1172_i_cdata_wr_12 BUFX3 $PINS A=FE_OFN5480_i_cdata_wr_12 Y=cdata_wr[12]
XFE_OFC1171_i_cdata_wr_13 BUFX3 $PINS A=FE_OFN5479_i_cdata_wr_13 Y=cdata_wr[13]
XFE_OFC1170_i_cdata_wr_14 BUFX3 $PINS A=FE_OFN5478_i_cdata_wr_14 Y=cdata_wr[14]
XFE_OFC1169_i_cdata_wr_15 BUFX3 $PINS A=FE_OFN5477_i_cdata_wr_15 Y=cdata_wr[15]
XFE_OFC1168_i_cdata_wr_16 BUFX3 $PINS A=FE_OFN5476_i_cdata_wr_16 Y=cdata_wr[16]
XFE_OFC1167_i_cdata_wr_17 BUFX3 $PINS A=FE_OFN5475_i_cdata_wr_17 Y=cdata_wr[17]
XFE_OFC1166_i_cdata_wr_18 BUFX3 $PINS A=FE_OFN5474_i_cdata_wr_18 Y=cdata_wr[18]
XFE_OFC1165_i_cdata_wr_19 BUFX3 $PINS A=FE_OFN5473_i_cdata_wr_19 Y=cdata_wr[19]
XFE_OFC1164_i_caddr_wr_0 BUFX3 $PINS A=FE_OFN5472_i_caddr_wr_0 Y=caddr_wr[0]
XFE_OFC1163_i_caddr_wr_1 BUFX3 $PINS A=FE_OFN5471_i_caddr_wr_1 Y=caddr_wr[1]
XFE_OFC1162_i_caddr_wr_2 BUFX3 $PINS A=FE_OFN5470_i_caddr_wr_2 Y=caddr_wr[2]
XFE_OFC1161_i_caddr_wr_3 BUFX3 $PINS A=FE_OFN5469_i_caddr_wr_3 Y=caddr_wr[3]
XFE_OFC1160_i_caddr_wr_4 BUFX3 $PINS A=FE_OFN5468_i_caddr_wr_4 Y=caddr_wr[4]
XFE_OFC1159_i_caddr_wr_5 BUFX3 $PINS A=FE_OFN5467_i_caddr_wr_5 Y=caddr_wr[5]
XFE_OFC1158_i_caddr_wr_6 BUFX3 $PINS A=FE_OFN5466_i_caddr_wr_6 Y=caddr_wr[6]
XFE_OFC1157_i_caddr_wr_7 BUFX3 $PINS A=FE_OFN5465_i_caddr_wr_7 Y=caddr_wr[7]
XFE_OFC1156_i_caddr_wr_9 BUFX3 $PINS A=FE_OFN5464_i_caddr_wr_9 Y=caddr_wr[9]
XFE_OFC1155_i_caddr_wr_10 BUFX3 $PINS A=FE_OFN5463_i_caddr_wr_10 Y=caddr_wr[10]
XFE_OFC1154_i_caddr_wr_11 BUFX3 $PINS A=FE_OFN5462_i_caddr_wr_11 Y=caddr_wr[11]
XFE_OFC1153_i_cwr BUFX3 $PINS A=FE_OFN5461_i_cwr Y=cwr
XFE_OFC1152_i_iaddr_0 BUFX3 $PINS A=FE_OFN5460_i_iaddr_0 Y=iaddr[0]
XFE_OFC1151_i_iaddr_1 BUFX3 $PINS A=FE_OFN5459_i_iaddr_1 Y=iaddr[1]
XFE_OFC1150_i_iaddr_2 BUFX3 $PINS A=FE_OFN5458_i_iaddr_2 Y=iaddr[2]
XFE_OFC1149_i_iaddr_3 BUFX3 $PINS A=FE_OFN5457_i_iaddr_3 Y=iaddr[3]
XFE_OFC1148_i_iaddr_4 BUFX3 $PINS A=FE_OFN5456_i_iaddr_4 Y=iaddr[4]
XFE_OFC1147_i_iaddr_5 BUFX3 $PINS A=FE_OFN5455_i_iaddr_5 Y=iaddr[5]
XFE_OFC1146_i_iaddr_6 BUFX3 $PINS A=FE_OFN5454_i_iaddr_6 Y=iaddr[6]
XFE_OFC1145_i_iaddr_7 BUFX3 $PINS A=FE_OFN5453_i_iaddr_7 Y=iaddr[7]
XFE_OFC1144_i_iaddr_8 BUFX3 $PINS A=FE_OFN5452_i_iaddr_8 Y=iaddr[8]
XFE_OFC1143_i_iaddr_9 BUFX3 $PINS A=FE_OFN5451_i_iaddr_9 Y=iaddr[9]
XFE_OFC1142_i_iaddr_10 BUFX3 $PINS A=FE_OFN5450_i_iaddr_10 Y=iaddr[10]
XFE_OFC1141_i_iaddr_11 BUFX3 $PINS A=FE_OFN5449_i_iaddr_11 Y=iaddr[11]
XFE_OFC1140_i_busy BUFX3 $PINS A=FE_OFN5448_i_busy Y=busy
XFE_DBTC1187_a_cnt_7 INVXL $PINS A=FE_OFN5608_a_cnt_7 Y=FE_DBTN1187_a_cnt_7
XFE_DBTC1184_register_3_11 INVX4 $PINS A=FE_OFN5548_register_3__11
+ Y=FE_DBTN1184_register_3_11
XFE_DBTC1182_n6663 INVXL $PINS A=n6663 Y=FE_DBTN1182_n6663
XFE_DBTC1157_register_2_13 INVX4 $PINS A=FE_OFN5535_register_2__13
+ Y=FE_DBTN1157_register_2_13
XFE_RC_494_0 NAND2X1 $PINS A=n6775 B=n4554 Y=FE_RN_274_0
XFE_RC_493_0 NAND2X2 $PINS A=n4932 B=n4553 Y=FE_RN_275_0
XFE_RC_489_0 NAND2X1 $PINS A=FE_OCPN6203_n5238 B=FE_OFN5989_register_6__13
+ Y=FE_RN_272_0
XFE_RC_488_0 AOI22X1 $PINS A0=FE_OFN5653_n4656 A1=CMF1[13] B0=FE_OCPN6199_n5237
+ B1=FE_OFN5579_register_7__13 Y=FE_RN_273_0
XFE_RC_487_0 AND2X2 $PINS A=FE_RN_273_0 B=FE_RN_272_0 Y=n5884
XFE_RC_485_0 NOR2BX4 $PINS AN=n4786 B=n4396 Y=n5223
XFE_RC_484_0 AOI222X2 $PINS A0=FE_OCPN2341_n5341 A1=register[4][7] B0=n5342
+ B1=FE_OFN5564_register_5__7 C0=FE_OFN5978_n5340 C1=n125 Y=n5897
XFE_RC_481_0 AOI2BB2X4 $PINS A0N=FE_RN_270_0 A1N=FE_RN_103_0 B0=n6646
+ B1=FE_RN_105_0 Y=FE_RN_106_0
XFE_RC_479_0 OR2X1 $PINS A=n4479 B=n6708 Y=FE_RN_269_0
XFE_RC_478_0 NAND2X2 $PINS A=n4632 B=FE_RN_269_0 Y=n4634
XFE_RC_477_0 NAND2X1 $PINS A=n5342 B=register[5][8] Y=FE_RN_267_0
XFE_RC_476_0 AOI22X1 $PINS A0=n5341 A1=FE_OFN5556_register_4__8
+ B0=FE_OFN5978_n5340 B1=n124 Y=FE_RN_268_0
XFE_RC_475_0 AND2X2 $PINS A=FE_RN_268_0 B=FE_RN_267_0 Y=n5895
XFE_RC_474_0 NAND2X1 $PINS A=FE_OCPN6195_n5002 B=FE_OFN5527_register_1__4
+ Y=FE_RN_265_0
XFE_RC_473_0 AOI22X1 $PINS A0=FE_OFN6125_n5007 A1=register[0][4]
+ B0=FE_OFN6130_n5000 B1=n223 Y=FE_RN_266_0
XFE_RC_472_0 AND2X2 $PINS A=FE_RN_266_0 B=FE_RN_265_0 Y=n5744
XFE_RC_471_0 OAI221XL $PINS A0=FE_OFN6013_n5336 A1=n5023 B0=n5335 B1=N1424
+ C0=n5633 Y=n1766
XFE_RC_468_0_dup NAND3BX4 $PINS AN=FE_RN_31 B=FE_RN_93_0 C=FE_RN_92_0
+ Y=FE_RN_29
XFE_RC_470_0 AOI222X2 $PINS A0=n4932 A1=FE_OFN5609_a_cnt_6
+ B0=FE_OCPN5439_FE_OFN244_n4560 B1=FE_RN_38_0 C0=n6634 C1=n4596 Y=n4595
XFE_RC_469_0 AOI222X1 $PINS A0=FE_OCPN6193_n5223 A1=FE_OFN5747_N609
+ B0=FE_OFN6151_n5224 B1=FE_OFN6038_register_2__5
+ C0=FE_OCPN6248_FE_DBTN1185_n4720 C1=FE_OFN5620_CMF0_5 Y=n5741
XFE_RC_467_0 NAND2X1 $PINS A=FE_OCPN6203_n5238 B=FE_OFN5572_register_6__6
+ Y=FE_RN_263_0
XFE_RC_465_0 AND2X2 $PINS A=FE_RN_264_0 B=FE_RN_263_0 Y=n5898
XFE_RC_464_0 NAND2X1 $PINS A=FE_OFN6130_n5000 B=n222 Y=FE_RN_260_0
XFE_RC_463_0 NAND2X1 $PINS A=FE_OCPN6195_n5002 B=FE_OFN6015_register_1__5
+ Y=FE_RN_261_0
XFE_RC_462_0 NAND2X1 $PINS A=FE_OFN6125_n5007 B=register[0][5] Y=FE_RN_262_0
XFE_RC_461_0 AND3X2 $PINS A=FE_RN_262_0 B=FE_RN_261_0 C=FE_RN_260_0 Y=n5742
XFE_RC_460_0 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5029 B0=FE_OFN5957_n5634
+ B1=FE_DBTN1164_register_8_4 Y=n1776
XFE_RC_459_0 NAND2BX1 $PINS AN=FE_RN_35_0 B=n5117 Y=FE_RN_258_0
XFE_RC_458_0 CLKINVX4 $PINS A=FE_RN_259_0 Y=FE_RN_17_0
XFE_RC_457_0 NOR2X4 $PINS A=FE_OCPN6240_FE_DBTN7_n5276 B=FE_RN_258_0
+ Y=FE_RN_259_0
XFE_RC_456_0 NAND2BX2 $PINS AN=n6622 B=n5634 Y=n4998
XFE_RC_455_0 AND3X2 $PINS A=FE_OCPN2275_FE_RN_106_0 B=n4524
+ C=FE_OCPN2343_FE_RN_101_0 Y=n4391
XFE_RC_452_0 INVX1 $PINS A=n5919 Y=FE_RN_256_0
XFE_RC_451_0 NOR2X1 $PINS A=FE_RN_256_0 B=FE_RN_2_0 Y=FE_RN_3_0
XFE_RC_450_0 NAND3X2 $PINS A=n6625 B=FE_RN_65_0 C=FE_RN_242_0 Y=FE_RN_160_0
XFE_RC_449_0 OAI2BB1X4 $PINS A0N=FE_RN_49_0 A1N=FE_OCPN2372_n4632 B0=n4640
+ Y=FE_OFN444_n5346
XFE_RC_447_0 NAND2X1 $PINS A=FE_OCPN6257_FE_RN_6 B=FE_OCPN6233_register_5__4
+ Y=FE_RN_254_0
XFE_RC_446_0 AOI22X1 $PINS A0=n5341 A1=FE_OFN5814_register_4__4
+ B0=FE_OFN5978_n5340 B1=n128 Y=FE_RN_255_0
XFE_RC_445_0 AND2X2 $PINS A=FE_RN_255_0 B=FE_RN_254_0 Y=n5903
XFE_RC_443_0 CLKINVX8 $PINS A=FE_RN_253_0 Y=n6633
XFE_RC_442_0 NOR2X4 $PINS A=n6639 B=n4316 Y=FE_RN_253_0
XFE_RC_441_0 NAND3BX1 $PINS AN=n6639 B=n5679 C=FE_RN_4_0 Y=FE_RN_4
XFE_RC_440_0 OAI222XL $PINS A0=FE_OFN5647_n5531 A1=n5530 B0=n5328 B1=n5043
+ C0=n5533 C1=n5085 Y=n1916
XFE_RC_439_0 NAND2X1 $PINS A=FE_OCPN6258_FE_OFN444_n5346 B=n51 Y=FE_RN_243_0
XFE_RC_438_0 INVX1 $PINS A=FE_OFN5599_N8549 Y=FE_RN_244_0
XFE_RC_437_0 NOR2X1 $PINS A=FE_OCPN2340_FE_RN_10 B=n4620 Y=FE_RN_245_0
XFE_RC_434_0 NAND2X2 $PINS A=n6630 B=n4619 Y=FE_RN_248_0
XFE_RC_431_0 NAND2X4 $PINS A=FE_RN_250_0 B=FE_OFN5599_N8549 Y=FE_RN_251_0
XFE_RC_430_0 NAND3X2 $PINS A=FE_RN_251_0 B=FE_RN_246_0 C=FE_RN_243_0 Y=n1730
XFE_RC_429_0 INVX1 $PINS A=FE_RN_159_0 Y=FE_RN_242_0
XFE_RC_427_0 OAI222XL $PINS A0=FE_OFN6058_n5531 A1=n5537 B0=n5328
+ B1=FE_OFN228_i_idata_2 C0=n5533 C1=n5099 Y=n1907
XFE_RC_426_0 NAND3X4 $PINS A=n4594 B=n4595 C=n4593 Y=n4590
XFE_RC_425_0 OAI22X4 $PINS A0=n6637 A1=FE_RN_140_0 B0=n6633 B1=FE_RN_142_0
+ Y=FE_RN_17
XFE_RC_424_0 AND2X2 $PINS A=n6634 B=FE_RN_239_0 Y=FE_RN_240_0
XFE_RC_423_0 NOR2X2 $PINS A=n4566 B=n4571 Y=FE_RN_241_0
XFE_RC_422_0 NOR2X2 $PINS A=FE_RN_241_0 B=FE_RN_240_0 Y=FE_RN_126_0
XFE_RC_421_0 INVX1 $PINS A=n4570 Y=FE_RN_239_0
XFE_RC_418_0 NAND2X2 $PINS A=n6775 B=n4571 Y=FE_RN_236_0
XFE_RC_417_0 NAND2X1 $PINS A=n4932 B=n4579 Y=FE_RN_237_0
XFE_RC_416_0 CLKINVX4 $PINS A=FE_RN_238_0 Y=n4578
XFE_RC_415_0 NAND3BX2 $PINS AN=FE_RN_128_0 B=FE_RN_237_0 C=FE_RN_236_0
+ Y=FE_RN_238_0
XFE_RC_411_0 NOR2X1 $PINS A=FE_OCPN6261_n5636 B=FE_DBTN1164_register_8_4
+ Y=FE_RN_232_0
XFE_RC_410_0 AOI2BB1X1 $PINS A0N=n5029 A1N=FE_OFN6013_n5336 B0=FE_RN_232_0
+ Y=FE_RN_233_0
XFE_RC_409_0 NAND2X1 $PINS A=n5624 B=FE_RN_233_0 Y=n1775
XFE_RC_408_0 NAND2X1 $PINS A=FE_OCPN6258_FE_OFN444_n5346 B=n55 Y=FE_RN_228_0
XFE_RC_407_0 NAND2X1 $PINS A=n6630 B=n6692 Y=FE_RN_229_0
XFE_RC_406_0 NAND2X1 $PINS A=n6624 B=n4602 Y=FE_RN_230_0
XFE_RC_405_0 CLKINVX2 $PINS A=FE_RN_231_0 Y=n4600
XFE_RC_404_0 NAND3X1 $PINS A=FE_RN_230_0 B=FE_RN_229_0 C=FE_RN_228_0
+ Y=FE_RN_231_0
XFE_RC_403_0 OR2X2 $PINS A=n5051 B=FE_OFN6013_n5336 Y=FE_RN_226_0
XFE_RC_402_0 NOR2X1 $PINS A=n5335 B=FE_OFN5709_register_8__15 Y=FE_RN_227_0
XFE_RC_401_0 NAND3BX1 $PINS AN=FE_RN_227_0 B=FE_RN_226_0 C=n5584 Y=n1808
XFE_RC_399_0 NAND2BX1 $PINS AN=n5426 B=FE_OFN5565_register_5__6 Y=FE_RN_225_0
XFE_RC_398_0 NAND3X1 $PINS A=n5420 B=FE_RN_225_0 C=n5419 Y=n1838
XFE_RC_396_0 NAND3X1 $PINS A=n5408 B=n5407 C=n5409 Y=n1834
XFE_RC_394_0 NAND2BX1 $PINS AN=n4599 B=FE_RN_38_0 Y=FE_RN_223_0
XFE_RC_392_0 NOR2BX1 $PINS AN=FE_OFN5597_N8547 B=n4536 Y=FE_RN_159_0
XFE_RC_391_0 AND2X2 $PINS A=n5597 B=n5598 Y=FE_RN_221_0
XFE_RC_390_0 NAND2X1 $PINS A=n5596 B=FE_RN_221_0 Y=n1799
XFE_RC_389_0 AND2X2 $PINS A=n6685 B=N8545 Y=FE_RN_220_0
XFE_RC_388_0 NAND3X1 $PINS A=n6624 B=FE_RN_220_0 C=FE_OFN5594_N8543 Y=n4604
XFE_RC_387_0 NAND3X1 $PINS A=FE_RN_176_0 B=n5638 C=FE_RN_175_0 Y=n1763
XFE_RC_385_0 INVXL $PINS A=FE_RN_219_0 Y=n1722
XFE_RC_384_0 NOR4X2 $PINS A=n5848 B=n5847 C=n5846 D=n5845 Y=FE_RN_219_0
XFE_RC_382_0 NAND2X1 $PINS A=FE_OCPN6200_n5237 B=FE_OFN5783_register_7__9
+ Y=FE_RN_217_0
XFE_RC_381_0 OAI2BB1X2 $PINS A0N=CMF1[9] A1N=FE_OFN5653_n4656 B0=FE_RN_217_0
+ Y=FE_RN_218_0
XFE_RC_380_0 AOI21X1 $PINS A0=FE_OCPN6203_n5238 A1=FE_OFN5569_register_6__9
+ B0=FE_RN_218_0 Y=n5892
XFE_RC_379_0 OAI222X1 $PINS A0=FE_OFN5986_n5003 A1=FE_OFN205_i_cdata_rd_3
+ B0=FE_OFN6107_n5352 B1=n5475 C0=FE_OFN5983_n5231 C1=n5027 Y=n1928
XFE_RC_376_0 AOI222X4 $PINS A0=FE_OFN6130_n5000 A1=n218 B0=FE_OFN6125_n5007
+ B1=register[0][9] C0=FE_OCPN6195_n5002 C1=FE_OFN5524_register_1__9 Y=n5734
XFE_RC_375_0 NAND2X1 $PINS A=FE_OCPN6257_FE_RN_6 B=FE_OCPN6208_N1316
+ Y=FE_RN_214_0
XFE_RC_374_0 AOI22X1 $PINS A0=n5341 A1=FE_OFN5601_N1253 B0=FE_OFN5978_n5340
+ B1=n131 Y=FE_RN_215_0
XFE_RC_373_0 AND2X2 $PINS A=FE_RN_215_0 B=FE_RN_214_0 Y=n5909
XFE_RC_372_0 INVXL $PINS A=FE_RN_213_0 Y=n1703
XFE_RC_371_0 NOR4X1 $PINS A=n5880 B=n5879 C=n5878 D=n5877 Y=FE_RN_213_0
XFE_RC_370_0 NAND2X1 $PINS A=FE_OFN6151_n5224 B=FE_OFN5538_register_2__10
+ Y=FE_RN_211_0
XFE_RC_369_0 OAI2BB1X1 $PINS A0N=FE_OFN5616_CMF0_10
+ A1N=FE_OCPN6248_FE_DBTN1185_n4720 B0=FE_RN_211_0 Y=FE_RN_212_0
XFE_RC_368_0 AOI21X1 $PINS A0=FE_OCPN6193_n5223 A1=FE_OFN5549_register_3__10
+ B0=FE_RN_212_0 Y=n5731
XFE_RC_367_0 OAI2BB1X2 $PINS A0N=FE_OFN5598_N8548 A1N=FE_RN_160_0
+ B0=FE_RN_180_0 Y=n1733
XFE_RC_366_0 AND2X2 $PINS A=N8545 B=FE_OFN5594_N8543 Y=FE_RN_210_0
XFE_RC_365_0 NOR2X2 $PINS A=FE_OCPN2340_FE_RN_10 B=FE_RN_210_0 Y=n4608
XFE_RC_364_0 NAND3X2 $PINS A=n4598 B=n4589 C=n4597 Y=FE_RN_208_0
XFE_RC_362_0 NAND2X2 $PINS A=FE_RN_208_0 B=FE_DBTN1187_a_cnt_7 Y=FE_RN_112_0
XFE_RC_361_0 NAND2X1 $PINS A=n5342 B=FE_OFN5560_register_5__15 Y=FE_RN_206_0
XFE_RC_360_0 AOI22X1 $PINS A0=n5341 A1=register[4][15] B0=FE_OFN5978_n5340
+ B1=n117 Y=FE_RN_207_0
XFE_RC_359_0 AND2X4 $PINS A=FE_RN_207_0 B=FE_RN_206_0 Y=n5823
XFE_RC_358_0 AOI222X1 $PINS A0=FE_OCPN2336_n5002 A1=FE_OFN6002_register_1__11
+ B0=FE_OFN6130_n5000 B1=n216 C0=FE_OFN6125_n5007 C1=FE_OFN6019_register_0__11
+ Y=n5730
XFE_RC_357_0 NOR3X4 $PINS A=FE_RN_80_0 B=n4608 C=FE_OFN394_n4528 Y=n4603
XU3707_dup1 OAI21X4 $PINS A0=FE_OCPN6236_i_reset A1=FE_RN_27 B0=busy Y=FE_RN_16
XU3650_dup CLKINVX4 $PINS A=FE_RN_3 Y=FE_RN_15
XFE_RC_356_0 OAI221X2 $PINS A0=n4609 A1=FE_OFN5597_N8547 B0=n6625 B1=FE_RN_64_0
+ C0=n4610 Y=n1736
XFE_RC_355_0 INVX1 $PINS A=n45 Y=FE_RN_204_0
XFE_RC_354_0 NOR2BX1 $PINS AN=FE_OCPN6259_FE_OFN444_n5346 B=FE_RN_204_0
+ Y=FE_RN_205_0
XFE_RC_353_0 AOI21X4 $PINS A0=n4542 A1=FE_OFN5604_a_cnt_11 B0=FE_RN_205_0
+ Y=n4547
XFE_RC_352_0 INVX1 $PINS A=n4535 Y=n6624
XFE_RC_349_0 NOR2X1 $PINS A=FE_OCPN6261_n5636 B=FE_DBTN1172_register_8_10
+ Y=FE_RN_199_0
XFE_RC_347_0 NOR2BX1 $PINS AN=idata[10] B=FE_OFN6013_n5336 Y=FE_RN_201_0
XFE_RC_346_0 NOR2X1 $PINS A=FE_RN_201_0 B=FE_RN_199_0 Y=FE_RN_202_0
XFE_RC_345_0 NAND2X1 $PINS A=n5604 B=FE_RN_202_0 Y=n1793
XFE_RC_344_0 NOR2X1 $PINS A=n5335 B=FE_OFN5586_register_8__9 Y=FE_RN_196_0
XFE_RC_343_0 NOR2X1 $PINS A=n5039 B=FE_OFN6013_n5336 Y=FE_RN_197_0
XFE_RC_342_0 NOR2X2 $PINS A=FE_RN_197_0 B=FE_RN_196_0 Y=FE_RN_198_0
XFE_RC_341_0 NAND2X1 $PINS A=n5608 B=FE_RN_198_0 Y=n1790
XFE_RC_339_0 NOR2BX1 $PINS AN=busy B=n4316 Y=FE_RN_195_0
XFE_RC_338_0 OAI21X4 $PINS A0=FE_OCPN6236_i_reset A1=FE_RN_27 B0=FE_RN_195_0
+ Y=FE_RN_194_0
XFE_RC_337_0 NOR2X1 $PINS A=FE_OCPN6261_n5636 B=FE_DBTN38_register_8_6
+ Y=FE_RN_192_0
XFE_RC_336_0 AOI2BB1X1 $PINS A0N=n5033 A1N=FE_OFN6013_n5336 B0=FE_RN_192_0
+ Y=FE_RN_193_0
XFE_RC_335_0 NAND2X1 $PINS A=n5617 B=FE_RN_193_0 Y=n1781
XFE_RC_333_0 NOR2X1 $PINS A=n5335 B=FE_OFN5719_register_8__5 Y=FE_RN_190_0
XFE_RC_332_0 AOI2BB1X1 $PINS A0N=n5031 A1N=FE_OFN6013_n5336 B0=FE_RN_190_0
+ Y=FE_RN_191_0
XFE_RC_331_0 NAND2X1 $PINS A=n5620 B=FE_RN_191_0 Y=n1778
XFE_RC_328_0 NOR2X1 $PINS A=n5697 B=n5696 Y=FE_RN_188_0
XFE_RC_327_0 NOR2X1 $PINS A=n5699 B=n5698 Y=FE_RN_189_0
XFE_RC_326_0 NAND2X1 $PINS A=FE_RN_189_0 B=FE_RN_188_0 Y=n1686
XFE_RC_325_0 NOR2X1 $PINS A=n5712 B=n5711 Y=FE_RN_186_0
XFE_RC_324_0 NOR2X1 $PINS A=n5714 B=n5713 Y=FE_RN_187_0
XFE_RC_323_0 NAND2X1 $PINS A=FE_RN_187_0 B=FE_RN_186_0 Y=n1668
XFE_RC_322_0 NAND2BX1 $PINS AN=FE_OFN5760_FE_RN_74_0 B=FE_RN_23_0 Y=FE_RN_183_0
XFE_RC_321_0 NOR2X1 $PINS A=FE_OCPN6261_n5636 B=FE_OFN306_register_8__16
+ Y=FE_RN_184_0
XFE_RC_320_0 AOI2BB1X1 $PINS A0N=n5053 A1N=FE_OFN6013_n5336 B0=FE_RN_184_0
+ Y=FE_RN_185_0
XFE_RC_319_0 NAND2X1 $PINS A=n5582 B=FE_RN_185_0 Y=n1811
XFE_RC_317_0 OAI21X2 $PINS A0=n4621 A1=FE_RN_183_0 B0=FE_RN_40_0 Y=FE_RN_59_0
XFE_RC_316_0 NOR2X4 $PINS A=FE_OCPN5439_FE_OFN244_n4560 B=FE_OFN5760_FE_RN_74_0
+ Y=FE_RN_182_0
XFE_RC_313_0 NOR2X2 $PINS A=FE_RN_20_0 B=FE_RN_158_0 Y=FE_RN_180_0
XFE_RC_311_0 INVXL $PINS A=FE_RN_90_0 Y=FE_RN_179_0
XFE_RC_309_0 AND3X2 $PINS A=n4611 B=n6679 C=FE_OFN5597_N8547 Y=FE_RN_178_0
XFE_RC_308_0 NAND2X1 $PINS A=n6624 B=FE_RN_178_0 Y=n4612
XFE_RC_307_0 NAND3X2 $PINS A=n4547 B=n4545 C=FE_OFN5667_n4546 Y=n1757
XFE_RC_304_0 OR2X2 $PINS A=FE_OCPN6261_n5636 B=FE_DBTN8_N1034 Y=FE_RN_175_0
XFE_RC_303_0 OR2X2 $PINS A=n5021 B=FE_OFN6013_n5336 Y=FE_RN_176_0
XFE_RC_301_0 NOR2X1 $PINS A=FE_OFN5960_n5348 B=FE_DBTN58_register_7_14
+ Y=FE_RN_174_0
XFE_RC_300_0 AOI21X1 $PINS A0=cdata_rd[14] A1=n5226 B0=FE_RN_174_0 Y=n5588
XFE_RC_299_0 NAND2X1 $PINS A=FE_OCPN6259_FE_OFN444_n5346 B=n44 Y=FE_RN_166_0
XFE_RC_298_0 NAND2X2 $PINS A=n4540 B=n6668 Y=FE_RN_167_0
XFE_RC_297_0 OAI2BB1X4 $PINS A0N=FE_OFN5604_a_cnt_11 A1N=n4541 B0=FE_RN_167_0
+ Y=FE_RN_168_0
XFE_RC_296_0 OAI21X4 $PINS A0=n4542 A1=FE_RN_168_0 B0=a_cnt[12] Y=FE_RN_169_0
XFE_RC_295_0 INVX1 $PINS A=a_cnt[12] Y=FE_RN_170_0
XFE_RC_294_0 NAND2X2 $PINS A=n4544 B=n6668 Y=FE_RN_171_0
XFE_RC_290_0 AOI22X4 $PINS A0=n4573 A1=FE_OFN5606_a_cnt_9
+ B0=FE_OCPN6259_FE_OFN444_n5346 B1=n47 Y=n4575
XFE_RC_286_0 AOI222X1 $PINS A0=FE_OCPN2334_n5002 A1=FE_OFN5521_register_1__15
+ B0=FE_OFN6125_n5007 B1=n6772 C0=FE_OFN6130_n5000 C1=n212 Y=n5677
XFE_RC_283_0 INVX1 $PINS A=n4572 Y=FE_RN_163_0
XFE_RC_282_0 CLKINVX3 $PINS A=n4581 Y=FE_RN_164_0
XFE_RC_281_0 OAI2BB1X4 $PINS A0N=FE_RN_163_0 A1N=FE_RN_164_0 B0=n6673 Y=n4574
XFE_RC_280_0 NOR2X1 $PINS A=n5705 B=n5704 Y=FE_RN_161_0
XFE_RC_279_0 NOR2X1 $PINS A=n5707 B=n5706 Y=FE_RN_162_0
XFE_RC_278_0 NAND2X1 $PINS A=FE_RN_162_0 B=FE_RN_161_0 Y=n1669
XFE_RC_276_0 AND2X2 $PINS A=n52 B=FE_OCPN6258_FE_OFN444_n5346 Y=FE_RN_158_0
XFE_RC_272_0 NOR2X2 $PINS A=n5335 B=FE_DBTN39_register_8_7 Y=FE_RN_154_0
XFE_RC_270_0 NOR2BX1 $PINS AN=FE_OFN5674_i_idata_7 B=FE_OFN6013_n5336
+ Y=FE_RN_156_0
XFE_RC_269_0 NOR2X1 $PINS A=FE_RN_156_0 B=FE_RN_154_0 Y=FE_RN_157_0
XFE_RC_268_0 NAND2X1 $PINS A=n5614 B=FE_RN_157_0 Y=n1784
XFE_RC_263_0 AOI21X1 $PINS A0=FE_OCPN6259_FE_OFN444_n5346 A1=n46 B0=n4544
+ Y=FE_RN_147_0
XFE_RC_262_0 AOI31X1 $PINS A0=n4572 A1=n6669 A2=FE_OFN5606_a_cnt_9 B0=n6636
+ Y=FE_RN_148_0
XFE_RC_260_0 NAND2X2 $PINS A=n4541 B=FE_OFN5606_a_cnt_9 Y=FE_RN_150_0
XFE_RC_259_0 OAI2BB1X2 $PINS A0N=n6673 A1N=n4540 B0=FE_RN_150_0 Y=FE_RN_151_0
XFE_RC_258_0 OAI21X4 $PINS A0=FE_RN_151_0 A1=n4573 B0=FE_OFN5605_a_cnt_10
+ Y=FE_RN_152_0
XFE_RC_256_0 NOR2X2 $PINS A=FE_OCPN6261_n5636 B=FE_OFN5732_register_8__8
+ Y=FE_RN_143_0
XFE_RC_254_0 NOR2BX1 $PINS AN=idata[8] B=FE_OFN6013_n5336 Y=FE_RN_145_0
XFE_RC_253_0 NOR2X1 $PINS A=FE_RN_145_0 B=FE_RN_143_0 Y=FE_RN_146_0
XFE_RC_252_0 NAND2X1 $PINS A=FE_RN_146_0 B=n5611 Y=n1787
XFE_RC_251_0 OR2X2 $PINS A=n4641 B=n5288 Y=FE_RN_140_0
XFE_RC_250_0 INVX1 $PINS A=n4643 Y=FE_RN_141_0
XFE_RC_249_0 AOI21X1 $PINS A0=n4387 A1=n4637 B0=FE_RN_141_0 Y=FE_RN_142_0
XFE_RC_247_0 INVX1 $PINS A=n4551 Y=FE_RN_138_0
XFE_RC_246_0 NOR2BX1 $PINS AN=n6634 B=FE_RN_138_0 Y=FE_RN_139_0
XFE_RC_242_0 NAND2BX1 $PINS AN=FE_OFN6173_n4567 B=n4630 Y=FE_RN_137_0
XFE_RC_237_0 OR2X2 $PINS A=n5335 B=FE_DBTN43_register_8_11 Y=FE_RN_131_0
XFE_RC_235_0 NAND2BX1 $PINS AN=FE_OFN6013_n5336 B=FE_OFN6139_i_idata_11
+ Y=FE_RN_133_0
XFE_RC_234_0 NAND3X1 $PINS A=n5601 B=FE_RN_133_0 C=FE_RN_131_0 Y=n1796
XFE_RC_227_0 NOR2BXL $PINS AN=n6634 B=FE_RN_239_0 Y=FE_RN_128_0
XFE_RC_224_0 NAND2X2 $PINS A=FE_RN_126_0 B=n4586 Y=n4581
XU3330_dup NOR2X4 $PINS A=n4556 B=n6775 Y=FE_RN_9
XFE_RC_217_0 NOR2X4 $PINS A=FE_RN_60_0 B=n5754 Y=n5007
XFE_RC_214_0 NOR2X1 $PINS A=n5866 B=n5865 Y=FE_RN_119_0
XFE_RC_213_0 NOR2X1 $PINS A=n5867 B=n5868 Y=FE_RN_120_0
XFE_RC_212_0 NAND2X1 $PINS A=FE_RN_120_0 B=FE_RN_119_0 Y=n1704
XFE_RC_211_0 AND2X2 $PINS A=n4386 B=n4410 Y=FE_RN_118_0
XFE_RC_210_0 NOR2X2 $PINS A=FE_OCPN6197_FE_DBTN7_n5276 B=FE_RN_118_0 Y=n4409
XFE_OCPC1127_n5824 CLKINVX4 $PINS A=n5824 Y=FE_RN_78_0
XFE_RC_209_0 INVX1 $PINS A=n4339 Y=FE_RN_117_0
XFE_RC_206_0 NOR2X1 $PINS A=FE_RN_9 B=FE_RN_111_0 Y=FE_RN_80_0
XFE_RC_196_0 INVX1 $PINS A=n4607 Y=FE_RN_111_0
XFE_RC_190_0 NOR2X1 $PINS A=FE_OCPN6197_FE_DBTN7_n5276 B=n6622 Y=FE_RN_107_0
XFE_RC_188_0 OAI2BB1X2 $PINS A0N=n4387 A1N=FE_RN_107_0 B0=n4520 Y=n5634
XFE_RC_186_0 AOI31X1 $PINS A0=n6700 A1=n4650 A2=n6698 B0=n6652 Y=FE_RN_96_0
XFE_RC_185_0 OAI21XL $PINS A0=n4387 A1=n5260 B0=n6641 Y=FE_RN_97_0
XFE_RC_184_0 OAI2BB1X1 $PINS A0N=n4627 A1N=n5287 B0=n6645 Y=FE_RN_98_0
XFE_RC_183_0 NAND3BX1 $PINS AN=n4388 B=FE_RN_98_0 C=FE_RN_97_0 Y=FE_RN_99_0
XFE_RC_182_0 OR3XL $PINS A=FE_RN_99_0 B=n4527 C=FE_RN_96_0 Y=FE_RN_100_0
XFE_RC_181_0 NAND2X2 $PINS A=FE_OFN5946_FE_DBTN7_n5276 B=FE_RN_100_0
+ Y=FE_RN_101_0
XFE_RC_180_0 NOR2X1 $PINS A=r_cnt[3] B=N425 Y=FE_RN_102_0
XFE_RC_179_0 NOR2BX1 $PINS AN=n6700 B=FE_RN_102_0 Y=FE_RN_103_0
XFE_RC_177_0 NAND2X1 $PINS A=n4523 B=n4650 Y=FE_RN_105_0
XFE_RC_170_0 OR2X2 $PINS A=FE_OCPN6197_FE_DBTN7_n5276 B=n4477 Y=FE_RN_92_0
XFE_RC_169_0 OR2X4 $PINS A=FE_OFN165_n4478 B=n4396 Y=FE_RN_93_0
XFE_RC_167_0 NOR2BX2 $PINS AN=n4530 B=FE_RN_16_0 Y=FE_RN_91_0
XFE_RC_166_0 NAND3X1 $PINS A=FE_RN_45_0 B=FE_RN_33_0 C=FE_RN_91_0 Y=n1761
XFE_RC_163_0 NOR2BX1 $PINS AN=n4636 B=n5287 Y=FE_RN_90_0
XFE_RC_151_0 OAI21X4 $PINS A0=FE_RN_78_0 A1=n6690 B0=FE_RN_37_0 Y=n4718
XFE_RC_150_0 NOR2X4 $PINS A=FE_OFN6056_FE_RN_5 B=n6698 Y=FE_RN_81_0
XFE_RC_149_0 NOR2X4 $PINS A=FE_OCPN6197_FE_DBTN7_n5276 B=n4442 Y=FE_RN_82_0
XFE_RC_141_0 AND2X2 $PINS A=n4597 B=n4622 Y=FE_RN_77_0
XFE_RC_140_0 NAND2X4 $PINS A=n4623 B=FE_RN_77_0 Y=n1727
XFE_RC_139_0 AND2X4 $PINS A=n4524 B=n4525 Y=FE_RN_76_0
XFE_RC_138_0 NAND2X4 $PINS A=FE_RN_76_0 B=n4520 Y=n5348
XFE_RC_137_0 AOI21X1 $PINS A0=n6703 A1=n6644 B0=n4788 Y=FE_RN_75_0
XFE_RC_130_0 INVX1 $PINS A=n5180 Y=FE_RN_70_0
XFE_RC_129_0 INVX1 $PINS A=n5182 Y=FE_RN_71_0
XFE_RC_128_0 NAND3BX2 $PINS AN=n5181 B=FE_RN_70_0 C=FE_RN_71_0 Y=n5012
XFE_RC_124_0 NOR2X4 $PINS A=FE_OFN5656_n4720 B=n6690 Y=n4786
XFE_RC_116_0 INVX1 $PINS A=FE_OFN5597_N8547 Y=FE_RN_64_0
XFE_RC_115_0 NAND2BX1 $PINS AN=FE_OCPN2340_FE_RN_10 B=FE_RN_64_0 Y=FE_RN_65_0
XFE_RC_113_0 CLKINVX4 $PINS A=n4786 Y=FE_RN_60_0
XFE_RC_107_0 AND2X2 $PINS A=FE_OCPN6193_n5223 B=FE_OFN5592_N611 Y=FE_RN_57_0
XFE_RC_106_0 AOI221X1 $PINS A0=FE_OFN6151_n5224 A1=FE_OFN5541_register_2__7
+ B0=FE_OCPN6248_FE_DBTN1185_n4720 B1=CMF0[7] C0=FE_RN_57_0 Y=n5737
XFE_RC_104_0 AND2X2 $PINS A=n6699 B=n6644 Y=FE_RN_56_0
XFE_RC_103_0 NAND2X2 $PINS A=FE_OFN5639_FE_RN_194_0 B=FE_RN_56_0 Y=n4407
XFE_RC_95_0 NAND2X4 $PINS A=FE_RN_53_0 B=n4756 Y=n4720
XFE_RC_93_0 INVXL $PINS A=n4639 Y=FE_RN_49_0
XFE_RC_91_0 OAI2BB1X1 $PINS A0N=FE_OCPN2276_n4632 A1N=FE_RN_49_0 B0=n4640
+ Y=n5346
XFE_RC_80_0 NAND2X1 $PINS A=n4533 B=FE_DBTN24_N8543 Y=FE_RN_45_0
XFE_RC_78_0 INVX1 $PINS A=n4621 Y=n6631
XFE_RC_77_0 INVXL $PINS A=FE_OFN5609_a_cnt_6 Y=FE_RN_38_0
XFE_RC_76_0 AND2X2 $PINS A=FE_OFN5599_N8549 B=FE_OFN5759_FE_RN_74_0
+ Y=FE_RN_39_0
XFE_RC_75_0 AOI21X1 $PINS A0=FE_RN_23_0 A1=FE_RN_39_0 B0=FE_RN_38_0
+ Y=FE_RN_40_0
XFE_RC_68_0 NAND2BX2 $PINS AN=n5824 B=n4688 Y=n4656
XFE_RC_67_0 NAND2X2 $PINS A=n5833 B=FE_OFN5603_n5235 Y=FE_RN_37_0
XFE_RC_65_0 AND2X2 $PINS A=n4754 B=n4793 Y=FE_RN_35_0
XFE_RC_64_0 NOR2X4 $PINS A=FE_OCPN6240_FE_DBTN7_n5276 B=FE_RN_35_0 Y=n5919
XFE_RC_59_0 NAND2BX1 $PINS AN=FE_OCPN5436_n4528 B=FE_OFN5594_N8543 Y=FE_RN_33_0
XU3273_dup NOR2X4 $PINS A=n6639 B=n4316 Y=FE_RN_7
XU5690_dup AND2X2 $PINS A=n4718 B=n6774 Y=FE_RN_6
XFE_RC_44_0 OR2X2 $PINS A=FE_OCPN6249_n4567 B=n4630 Y=FE_RN_23_0
XFE_RC_40_0 NAND2X4 $PINS A=FE_RN_22_0 B=n4568 Y=n4544
XFE_RC_39_0 NAND2X1 $PINS A=n6631 B=n4612 Y=FE_RN_20_0
XFE_RC_37_0 NAND2X1 $PINS A=n4540 B=FE_DBTN1187_a_cnt_7 Y=FE_RN_18_0
XFE_RC_36_0 OAI2BB1X4 $PINS A0N=FE_OFN5608_a_cnt_7 A1N=n4541 B0=FE_RN_18_0
+ Y=FE_RN_19_0
XFE_RC_8_0_dup NAND2X4 $PINS A=FE_RN_4 B=n4634 Y=FE_RN_3
XFE_RC_33_0 NAND2X4 $PINS A=n5920 B=FE_RN_17_0 Y=n5678
XFE_RC_32_0 AND2X2 $PINS A=n4534 B=n4400 Y=FE_RN_16_0
XFE_RC_10_0 INVX1 $PINS A=n4633 Y=FE_RN_4_0
XFE_RC_9_0 NAND2BX4 $PINS AN=n6633 B=FE_RN_4_0 Y=FE_RN_5_0
XFE_RC_8_0 NAND2X4 $PINS A=FE_RN_5_0 B=n4634 Y=n4556
XFE_RC_6_0 INVX1 $PINS A=CMF1[15] Y=FE_RN_2_0
XFE_RC_4_0 NOR2X2 $PINS A=FE_RN_3_0 B=n5824 Y=n4910
XFE_OFC1099_n6771 CLKINVX8 $PINS A=n6771 Y=n5225
XFE_OFC1085_n4589 INVX2 $PINS A=n4589 Y=n6632
XFE_OFC1064_n4534 INVX1 $PINS A=n4534 Y=FE_OFN5398_n4534
XFE_OFC974_n4615 CLKINVX4 $PINS A=n4615 Y=n6625
XFE_OFC949_n5695 CLKINVX3 $PINS A=n5695 Y=n5916
XFE_OFC904_n5011 INVX2 $PINS A=n5011 Y=FE_OFN608_n5011
XFE_OFC890_register_2__9 INVX4 $PINS A=FE_OFN5539_register_2__9
+ Y=FE_OFN602_register_2__9
XFE_OFC873_n4937 CLKINVX3 $PINS A=FE_OFN5602_n4937 Y=n4939
XFE_OFC862_n5286 INVX4 $PINS A=n5286 Y=r2240/DIFF[5]
XFE_OFC848_n5560 CLKINVX3 $PINS A=n5560 Y=n5540
XFE_OFC840_register_8__14 CLKINVX3 $PINS A=FE_OFN5584_register_8__14
+ Y=FE_OFN304_register_8__14
XFE_OFC633_n5233 CLKINVX3 $PINS A=n5233 Y=n5426
XFE_OFC626_N1254 CLKINVX3 $PINS A=FE_OFN5557_register_4__2 Y=FE_DBTN14_N1254
XFE_OFC611_n4528 INVX4 $PINS A=FE_OCPN5436_n4528 Y=FE_OFN394_n4528
XFE_OFC601_register_0__11 CLKINVX3 $PINS A=FE_OFN6019_register_0__11
+ Y=FE_OFN388_register_0__11
XFE_OFC563_n4246 INVX1 $PINS A=n4246 Y=n6665
XFE_OFC533_N606 INVX4 $PINS A=FE_OFN5588_N606 Y=FE_OFN349_N606
XFE_OFC503_register_5__9 INVX1 $PINS A=FE_OFN5563_register_5__9
+ Y=FE_OFN329_register_5__9
XFE_OFC491_register_3__16 INVX4 $PINS A=FE_OFN5546_register_3__16
+ Y=FE_OFN75_register_3__16
XFE_OFC479_N610 INVX1 $PINS A=FE_OFN5591_N610 Y=FE_DBTN29_N610
XFE_OFC434_n4632 CLKINVX4 $PINS A=n4632 Y=n6637
XFE_OFC424_n4370 CLKINVX3 $PINS A=n4370 Y=n6618
XFE_OFC406_register_2__15 CLKINVX3 $PINS A=FE_OFN5533_register_2__15
+ Y=FE_OFN271_register_2__15
XFE_OFC375_register_8__6 CLKINVX3 $PINS A=FE_OFN5587_register_8__6
+ Y=FE_DBTN38_register_8_6
XFE_OFC338_n5235 INVX8 $PINS A=FE_OFN5603_n5235 Y=n6690
XFE_OFC331_register_3__10 INVX1 $PINS A=FE_OFN5549_register_3__10
+ Y=FE_DBTN105_register_3_10
XFE_OFC330_i_idata_2 CLKINVX3 $PINS A=idata[2] Y=FE_OFN228_i_idata_2
XFE_OFC316_i_cdata_rd_2 CLKINVX3 $PINS A=cdata_rd[2] Y=n5099
XFE_OFC299_n4396 INVX1 $PINS A=n4396 Y=n6708
XFE_OFC290_i_cdata_rd_3 INVX2 $PINS A=cdata_rd[3] Y=FE_OFN205_i_cdata_rd_3
XFE_OFC288_N1253 INVX1 $PINS A=FE_OFN5601_N1253 Y=FE_DBTN13_N1253
XFE_OFC285_register_5__10 CLKINVX3 $PINS A=FE_OFN5562_register_5__10
+ Y=FE_DBTN81_register_5_10
XFE_OFC280_i_idata_9 CLKINVX3 $PINS A=idata[9] Y=n5039
XFE_OFC278_i_idata_8 CLKINVX3 $PINS A=idata[8] Y=FE_OFN200_i_idata_8
XFE_OFC264_n4483 INVX1 $PINS A=n4483 Y=n6707
XFE_OFC228_n105 INVX1 $PINS A=n105 Y=n6766
XFE_OFC223_n6775 CLKINVX8 $PINS A=n6775 Y=n4566
XFE_OFC206_n6739 INVX4 $PINS A=n6739 Y=n4889
XFE_OFC190_n4478 CLKINVX4 $PINS A=FE_OCPN6188_n6646 Y=FE_OFN165_n4478
XFE_OFC185_N1697 INVX4 $PINS A=N1697 Y=FE_DBTN26_N1697
XFE_OFC121_CMF0_1 INVX1 $PINS A=CMF0[1] Y=FE_OFN123_CMF0_1
XFE_OFC117_CMF0_4 INVX1 $PINS A=CMF0[4] Y=FE_OFN119_CMF0_4
XFE_OFC115_CMF0_5 INVX1 $PINS A=FE_OFN5620_CMF0_5 Y=FE_OFN117_CMF0_5
XFE_OFC113_CMF0_6 INVX1 $PINS A=CMF0[6] Y=FE_OFN115_CMF0_6
XFE_OFC111_CMF0_7 INVX1 $PINS A=CMF0[7] Y=FE_OFN113_CMF0_7
XFE_OFC109_CMF0_8 INVX1 $PINS A=FE_OFN6265_CMF0_8 Y=FE_OFN111_CMF0_8
XFE_OFC106_CMF0_10 INVX1 $PINS A=FE_OFN5616_CMF0_10 Y=FE_OFN108_CMF0_10
XFE_OFC99_CMF0_16 INVX1 $PINS A=CMF0[16] Y=FE_OFN101_CMF0_16
XFE_OFC96_CMF0_18 INVX1 $PINS A=CMF0[18] Y=FE_OFN98_CMF0_18
XFE_OFC94_CMF0_19 INVX1 $PINS A=CMF0[19] Y=FE_OFN96_CMF0_19
XFE_OFC91_n4441 INVX1 $PINS A=n4441 Y=FE_OFN93_n4441
XFE_DBTC186_N882 INVX1 $PINS A=N882 Y=FE_DBTN186_N882
XFE_DBTC149_i_reset INVX12 $PINS A=FE_RN_2 Y=FE_DBTN149_i_reset
XFE_DBTC136_register_1_17 INVX1 $PINS A=FE_OFN6029_register_1__17
+ Y=FE_DBTN136_register_1_17
XFE_DBTC135_register_1_14 INVX1 $PINS A=FE_OFN5522_register_1__14
+ Y=FE_DBTN135_register_1_14
XFE_DBTC134_register_1_12 INVXL $PINS A=FE_OFN5997_register_1__12
+ Y=FE_DBTN134_register_1_12
XFE_DBTC133_register_1_10 INVX1 $PINS A=FE_OFN6003_register_1__10
+ Y=FE_DBTN133_register_1_10
XFE_DBTC132_register_1_8 INVX1 $PINS A=FE_OFN5525_register_1__8
+ Y=FE_DBTN132_register_1_8
XFE_DBTC131_register_1_5 INVX1 $PINS A=FE_OFN6015_register_1__5
+ Y=FE_DBTN131_register_1_5
XFE_DBTC130_register_1_3 INVX1 $PINS A=FE_OFN5528_register_1__3
+ Y=FE_DBTN130_register_1_3
XFE_DBTC126_register_2_16 INVX1 $PINS A=FE_OFN5532_register_2__16
+ Y=FE_DBTN126_register_2_16
XFE_DBTC89_register_5_19 INVXL $PINS A=FE_OFN5558_register_5__19
+ Y=FE_DBTN89_register_5_19
XFE_DBTC88_register_5_18 INVXL $PINS A=register[5][18]
+ Y=FE_DBTN88_register_5_18
XFE_DBTC87_register_5_17 INVXL $PINS A=register[5][17]
+ Y=FE_DBTN87_register_5_17
XFE_DBTC86_register_5_16 INVX1 $PINS A=FE_OFN5559_register_5__16
+ Y=FE_DBTN86_register_5_16
XFE_DBTC85_register_5_15 INVXL $PINS A=FE_OFN5560_register_5__15
+ Y=FE_DBTN85_register_5_15
XFE_DBTC84_register_5_14 INVX1 $PINS A=register[5][14]
+ Y=FE_DBTN84_register_5_14
XFE_DBTC83_register_5_13 INVX1 $PINS A=register[5][13]
+ Y=FE_DBTN83_register_5_13
XFE_DBTC82_register_5_12 INVX1 $PINS A=FE_OFN5561_register_5__12
+ Y=FE_DBTN82_register_5_12
XFE_DBTC79_register_5_5 INVXL $PINS A=register[5][5] Y=FE_DBTN79_register_5_5
XFE_DBTC59_register_7_15 INVXL $PINS A=register[7][15]
+ Y=FE_DBTN59_register_7_15
XFE_DBTC58_register_7_14 INVX1 $PINS A=FE_OFN5578_register_7__14
+ Y=FE_DBTN58_register_7_14
XFE_DBTC57_register_7_13 INVX1 $PINS A=FE_OFN5579_register_7__13
+ Y=FE_DBTN57_register_7_13
XFE_DBTC56_register_7_12 INVX1 $PINS A=FE_OFN5580_register_7__12
+ Y=FE_DBTN56_register_7_12
XFE_DBTC25_N1699 INVX1 $PINS A=N1699 Y=FE_DBTN25_N1699
XFE_DBTC24_N8543 INVX1 $PINS A=FE_OFN5594_N8543 Y=FE_DBTN24_N8543
XFE_DBTC22_n5504 CLKINVX8 $PINS A=n5504 Y=FE_DBTN22_n5504
XFE_DBTC12_N1252 INVX1 $PINS A=N707 Y=FE_DBTN12_N1252
XFE_DBTC9_N1143 INVX1 $PINS A=FE_OFN5998_register_1__0 Y=FE_DBTN9_N1143
XFE_DBTC1_n5754 INVX1 $PINS A=n5754 Y=FE_DBTN1_n5754
XU2623 NAND2X2 $PINS A=n5913 B=n6714 Y=n4807
Xgt_789 CONV_DW_cmp_0 $PINS A[35]=FE_UNCONNECTEDZ_0 A[34]=FE_UNCONNECTEDZ_1
+ A[33]=FE_UNCONNECTEDZ_2 A[32]=FE_UNCONNECTEDZ_3 A[31]=FE_UNCONNECTEDZ_4
+ A[30]=FE_UNCONNECTEDZ_5 A[29]=FE_UNCONNECTEDZ_6 A[28]=FE_UNCONNECTEDZ_7
+ A[27]=FE_UNCONNECTEDZ_8 A[26]=FE_UNCONNECTEDZ_9 A[25]=FE_UNCONNECTEDZ_10
+ A[24]=FE_UNCONNECTEDZ_11 A[23]=FE_UNCONNECTEDZ_12 A[22]=FE_UNCONNECTEDZ_13
+ A[21]=FE_UNCONNECTEDZ_14 A[20]=FE_UNCONNECTEDZ_15
+ A[19]=FE_OFN5576_register_7__19 A[18]=register[7][18] A[17]=register[7][17]
+ A[16]=FE_UNCONNECTEDZ_16 A[15]=register[7][15] A[14]=FE_DBTN58_register_7_14
+ A[13]=FE_OFN5579_register_7__13 A[12]=FE_DBTN56_register_7_12
+ A[11]=register[7][11] A[10]=FE_UNCONNECTEDZ_17 A[9]=FE_DBTN54_register_7_9
+ A[8]=register[7][8] A[7]=FE_OFN5896_register_7__7 A[6]=register[7][6]
+ A[5]=FE_OFN5581_register_7__5 A[4]=register[7][4] A[3]=FE_DBTN53_register_7_3
+ A[2]=FE_OFN5689_register_7__2 A[1]=register[7][1] A[0]=N965 B[35]=CMF1[35]
+ B[34]=CMF1[34] B[33]=CMF1[33] B[32]=CMF1[32] B[31]=CMF1[31] B[30]=CMF1[30]
+ B[29]=CMF1[29] B[28]=CMF1[28] B[27]=CMF1[27] B[26]=CMF1[26] B[25]=CMF1[25]
+ B[24]=CMF1[24] B[23]=CMF1[23] B[22]=CMF1[22] B[21]=CMF1[21] B[20]=CMF1[20]
+ B[19]=CMF1[19] B[18]=CMF1[18] B[17]=CMF1[17] B[16]=CMF1[16] B[15]=CMF1[15]
+ B[14]=CMF1[14] B[13]=CMF1[13] B[12]=CMF1[12] B[11]=CMF1[11] B[10]=CMF1[10]
+ B[9]=CMF1[9] B[8]=CMF1[8] B[7]=CMF1[7] B[6]=CMF1[6] B[5]=CMF1[5] B[4]=CMF1[4]
+ B[3]=CMF1[3] B[2]=FE_OFN5630_CMF1_2 B[1]=CMF1[1] B[0]=FE_OFN5631_CMF1_0
+ GE_LT_GT_LE=N14688 p1=FE_DBTN57_register_7_13 p2=FE_DBTN59_register_7_15
+ _register_7_18=register[7][18] _register_7_10=FE_OFN262_register_7__10
+ _register_7_16=FE_OFN5577_register_7__16 n5649=n5649
+ FE_OFN5783_register_7__9=FE_OFN5783_register_7__9
+ FE_OFN5853_FE_DBTN21_N1711=FE_OFN5853_FE_DBTN21_N1711
Xgt_783 CONV_DW_cmp_1 $PINS A[35]=FE_UNCONNECTEDZ_18 A[34]=FE_UNCONNECTEDZ_19
+ A[33]=FE_UNCONNECTEDZ_20 A[32]=FE_UNCONNECTEDZ_21 A[31]=FE_UNCONNECTEDZ_22
+ A[30]=FE_UNCONNECTEDZ_23 A[29]=FE_UNCONNECTEDZ_24 A[28]=FE_UNCONNECTEDZ_25
+ A[27]=FE_UNCONNECTEDZ_26 A[26]=FE_UNCONNECTEDZ_27 A[25]=FE_UNCONNECTEDZ_28
+ A[24]=FE_UNCONNECTEDZ_29 A[23]=FE_UNCONNECTEDZ_30 A[22]=FE_UNCONNECTEDZ_31
+ A[21]=FE_UNCONNECTEDZ_32 A[20]=FE_UNCONNECTEDZ_33 A[19]=register[6][19]
+ A[18]=FE_DBTN76_register_6_18 A[17]=register[6][17] A[16]=register[6][16]
+ A[15]=FE_OFN5984_register_6__15 A[14]=FE_DBTN72_register_6_14
+ A[13]=FE_OFN5989_register_6__13 A[12]=FE_DBTN70_register_6_12
+ A[11]=FE_OFN5568_register_6__11 A[10]=register[6][10] A[9]=register[6][9]
+ A[8]=FE_OFN5830_register_6__8 A[7]=FE_OFN5571_register_6__7
+ A[6]=FE_OFN5572_register_6__6 A[5]=FE_DBTN63_register_6_5
+ A[4]=FE_DBTN62_register_6_4 A[3]=FE_DBTN1183_register_6_3
+ A[2]=FE_DBTN1158_n4963 A[1]=FE_OFN5600_N872 A[0]=n5321 B[35]=CMF1[35]
+ B[34]=CMF1[34] B[33]=CMF1[33] B[32]=CMF1[32] B[31]=CMF1[31] B[30]=CMF1[30]
+ B[29]=CMF1[29] B[28]=CMF1[28] B[27]=CMF1[27] B[26]=CMF1[26] B[25]=CMF1[25]
+ B[24]=CMF1[24] B[23]=CMF1[23] B[22]=CMF1[22] B[21]=CMF1[21] B[20]=CMF1[20]
+ B[19]=CMF1[19] B[18]=CMF1[18] B[17]=CMF1[17] B[16]=CMF1[16] B[15]=CMF1[15]
+ B[14]=CMF1[14] B[13]=CMF1[13] B[12]=CMF1[12] B[11]=CMF1[11] B[10]=CMF1[10]
+ B[9]=CMF1[9] B[8]=CMF1[8] B[7]=CMF1[7] B[6]=CMF1[6] B[5]=CMF1[5] B[4]=CMF1[4]
+ B[3]=CMF1[3] B[2]=FE_OFN5630_CMF1_2 B[1]=CMF1[1] B[0]=FE_OFN5631_CMF1_0
+ GE_LT_GT_LE=N14687 p1=FE_DBTN71_register_6_13 p2=FE_DBTN73_register_6_15
+ FE_OFN54_register_6__9=FE_OFN5569_register_6__9
Xgte_764 CONV_DW_cmp_2 $PINS A[19]=FE_DBTN89_register_5_19
+ A[18]=register[5][18] A[17]=FE_DBTN87_register_5_17
+ A[16]=FE_OFN5559_register_5__16 A[15]=FE_OFN5560_register_5__15
+ A[14]=FE_DBTN84_register_5_14 A[13]=register[5][13]
+ A[12]=FE_DBTN82_register_5_12 A[11]=register[5][11]
+ A[10]=FE_DBTN81_register_5_10 A[9]=FE_OFN5563_register_5__9
+ A[8]=FE_OFN5932_register_5__8 A[7]=FE_OFN5564_register_5__7
+ A[6]=FE_OFN5565_register_5__6 A[5]=FE_DBTN79_register_5_5 A[4]=n5534
+ A[3]=FE_UNCONNECTEDZ_34 A[2]=register[5][2] A[1]=N1282 A[0]=FE_OFN5835_N1281
+ B[19]=FE_DBTN1177_register_4_19 B[18]=FE_OFN5703_register_4__18
+ B[17]=FE_OFN6069_n6728 B[16]=FE_OFN78_register_4__16
+ B[15]=FE_OFN5712_register_4__15 B[14]=FE_OFN79_register_4__14
+ B[13]=FE_OFN309_register_4__13 B[12]=FE_OFN5824_register_4__12
+ B[11]=FE_UNCONNECTEDZ_35 B[10]=FE_UNCONNECTEDZ_36 B[9]=FE_OFN5839_register_4__9
+ B[8]=FE_UNCONNECTEDZ_37 B[7]=register[4][7] B[6]=FE_DBTN1174_register_4_6
+ B[5]=FE_DBTN91_register_4_5 B[4]=register[4][4] B[3]=n4939
+ B[2]=FE_OFN5557_register_4__2 B[1]=FE_OFN5601_N1253 B[0]=register[4][0]
+ GE_LT_GT_LE=N14585 p1=FE_DBTN78_register_5_3
+ FE_OFN58_register_5__4=FE_OFN5721_register_5__4
+ _register_4_14=FE_OFN5552_register_4__14 _register_4_8=FE_OFN5556_register_4__8
+ _register_5_3=FE_OFN5743_register_5__3 _register_4_11=FE_OFN5865_register_4__11
+ _register_4_10=FE_OFN5874_register_4__10 _register_4_16=FE_OFN78_register_4__16
+ p_2=FE_OFN5602_n4937 FE_OCPN103_register_4__7=FE_OCPN6212_register_4__7
Xgt_750 CONV_DW_cmp_3 $PINS A[35]=FE_UNCONNECTEDZ_38 A[34]=FE_UNCONNECTEDZ_39
+ A[33]=FE_UNCONNECTEDZ_40 A[32]=FE_UNCONNECTEDZ_41 A[31]=FE_UNCONNECTEDZ_42
+ A[30]=FE_UNCONNECTEDZ_43 A[29]=FE_UNCONNECTEDZ_44 A[28]=FE_UNCONNECTEDZ_45
+ A[27]=FE_UNCONNECTEDZ_46 A[26]=FE_UNCONNECTEDZ_47 A[25]=FE_UNCONNECTEDZ_48
+ A[24]=FE_UNCONNECTEDZ_49 A[23]=FE_UNCONNECTEDZ_50 A[22]=FE_UNCONNECTEDZ_51
+ A[21]=FE_UNCONNECTEDZ_52 A[20]=FE_UNCONNECTEDZ_53
+ A[19]=FE_OFN6008_register_3__19 A[18]=FE_DBTN112_register_3_18
+ A[17]=FE_OFN6017_register_3__17 A[16]=FE_UNCONNECTEDZ_54
+ A[15]=FE_OCPN6210_register_3__15 A[14]=FE_OFN5766_register_3__14 A[13]=n5108
+ A[12]=FE_DBTN1171_register_3_12 A[11]=FE_OFN5548_register_3__11
+ A[10]=FE_OFN5549_register_3__10 A[9]=n5103 A[8]=FE_OFN5936_N612
+ A[7]=FE_UNCONNECTEDZ_55 A[6]=FE_OFN5591_N610 A[5]=FE_OFN5747_N609
+ A[4]=FE_DBTN31_N608 A[3]=FE_DBTN32_N607 A[2]=FE_OFN349_N606
+ A[1]=FE_OFN6040_N1177 A[0]=FE_OFN5775_n5319 B[35]=n5117 B[34]=n5118 B[33]=n5112
+ B[32]=n5111 B[31]=CMF0[31] B[30]=CMF0[30] B[29]=CMF0[29] B[28]=CMF0[28]
+ B[27]=CMF0[27] B[26]=CMF0[26] B[25]=CMF0[25] B[24]=CMF0[24] B[23]=CMF0[23]
+ B[22]=CMF0[22] B[21]=CMF0[21] B[20]=CMF0[20] B[19]=CMF0[19] B[18]=CMF0[18]
+ B[17]=CMF0[17] B[16]=CMF0[16] B[15]=FE_OFN5611_CMF0_15 B[14]=FE_OFN5612_CMF0_14
+ B[13]=FE_OFN5613_CMF0_13 B[12]=FE_OFN5614_CMF0_12 B[11]=FE_OFN5615_CMF0_11
+ B[10]=CMF0[10] B[9]=FE_OFN5617_CMF0_9 B[8]=CMF0[8] B[7]=CMF0[7] B[6]=CMF0[6]
+ B[5]=FE_OFN5620_CMF0_5 B[4]=CMF0[4] B[3]=FE_OFN5621_CMF0_3
+ B[2]=FE_OFN5622_CMF0_2 B[1]=CMF0[1] B[0]=CMF0[0] GE_LT_GT_LE=N14546
+ n5107=FE_OFN5934_n5107 p1=FE_OFN5878_register_3__15
+ FE_OFN101_CMF0_16=FE_OFN101_CMF0_16 FE_OFN98_CMF0_18=FE_OFN98_CMF0_18
+ FE_OFN96_CMF0_19=FE_OFN96_CMF0_19 FE_OFN123_CMF0_1=FE_OFN123_CMF0_1
+ FE_OFN119_CMF0_4=FE_OFN119_CMF0_4 FE_OFN111_CMF0_8=FE_OFN111_CMF0_8
+ FE_OFN115_CMF0_6=FE_OFN115_CMF0_6 FE_OFN117_CMF0_5=FE_OFN117_CMF0_5
+ FE_OFN113_CMF0_7=FE_OFN113_CMF0_7 FE_OFN108_CMF0_10=FE_OFN108_CMF0_10
+ _register_3_16=FE_OFN5546_register_3__16 N611=FE_OFN5592_N611
+ _register_3_18=FE_OFN5813_register_3__18
Xgt_742 CONV_DW_cmp_4 $PINS A[35]=FE_UNCONNECTEDZ_56 A[34]=FE_UNCONNECTEDZ_57
+ A[33]=FE_UNCONNECTEDZ_58 A[32]=FE_UNCONNECTEDZ_59 A[31]=FE_UNCONNECTEDZ_60
+ A[30]=FE_UNCONNECTEDZ_61 A[29]=FE_UNCONNECTEDZ_62 A[28]=FE_UNCONNECTEDZ_63
+ A[27]=FE_UNCONNECTEDZ_64 A[26]=FE_UNCONNECTEDZ_65 A[25]=FE_UNCONNECTEDZ_66
+ A[24]=FE_UNCONNECTEDZ_67 A[23]=FE_UNCONNECTEDZ_68 A[22]=FE_UNCONNECTEDZ_69
+ A[21]=FE_UNCONNECTEDZ_70 A[20]=FE_UNCONNECTEDZ_71
+ A[19]=FE_OFN5529_register_2__19 A[18]=FE_OFN5530_register_2__18
+ A[17]=FE_OFN5531_register_2__17 A[16]=FE_OFN5532_register_2__16
+ A[15]=FE_OFN5533_register_2__15 A[14]=FE_OFN5534_register_2__14
+ A[13]=FE_OFN5535_register_2__13 A[12]=FE_DBTN122_register_2_12
+ A[11]=FE_UNCONNECTEDZ_72 A[10]=FE_UNCONNECTEDZ_73 A[9]=FE_OFN5539_register_2__9
+ A[8]=FE_OFN5540_register_2__8 A[7]=FE_OFN5541_register_2__7
+ A[6]=FE_OFN5787_register_2__6 A[5]=FE_OFN6038_register_2__5
+ A[4]=FE_OFN5543_register_2__4 A[3]=n5219 A[2]=n5216
+ A[1]=FE_OFN5544_register_2__1 A[0]=N15861 B[35]=n5117 B[34]=n5118 B[33]=n5112
+ B[32]=n5111 B[31]=CMF0[31] B[30]=CMF0[30] B[29]=CMF0[29] B[28]=CMF0[28]
+ B[27]=CMF0[27] B[26]=CMF0[26] B[25]=CMF0[25] B[24]=CMF0[24] B[23]=CMF0[23]
+ B[22]=CMF0[22] B[21]=CMF0[21] B[20]=CMF0[20] B[19]=CMF0[19] B[18]=CMF0[18]
+ B[17]=CMF0[17] B[16]=CMF0[16] B[15]=FE_OFN5611_CMF0_15 B[14]=FE_OFN5612_CMF0_14
+ B[13]=FE_OFN5613_CMF0_13 B[12]=FE_OFN5614_CMF0_12 B[11]=FE_OFN5615_CMF0_11
+ B[10]=CMF0[10] B[9]=FE_OFN5617_CMF0_9 B[8]=CMF0[8] B[7]=CMF0[7] B[6]=CMF0[6]
+ B[5]=FE_OFN5620_CMF0_5 B[4]=CMF0[4] B[3]=FE_OFN5621_CMF0_3
+ B[2]=FE_OFN5622_CMF0_2 B[1]=CMF0[1] B[0]=CMF0[0] GE_LT_GT_LE=N14519 n5475=n5475
+ n5214=n5214 _register_2_10=FE_OFN5538_register_2__10
+ _register_2_11=FE_OFN5537_register_2__11 p1=FE_DBTN1157_register_2_13
+ p2=FE_OFN271_register_2__15 FE_OFN101_CMF0_16=FE_OFN101_CMF0_16
+ FE_OFN98_CMF0_18=FE_OFN98_CMF0_18 FE_OFN96_CMF0_19=FE_OFN96_CMF0_19
+ FE_OFN123_CMF0_1=FE_OFN123_CMF0_1 FE_OFN119_CMF0_4=FE_OFN119_CMF0_4
+ FE_OFN111_CMF0_8=FE_OFN111_CMF0_8 FE_OFN115_CMF0_6=FE_OFN115_CMF0_6
+ FE_OFN117_CMF0_5=FE_OFN117_CMF0_5 FE_OFN113_CMF0_7=FE_OFN113_CMF0_7
+ FE_OFN108_CMF0_10=FE_OFN108_CMF0_10
+ FE_OFN66_register_2__8=FE_OFN5751_register_2__8
Xgte_732 CONV_DW_cmp_5 $PINS A[19]=register[1][19] A[18]=n5105
+ A[17]=FE_DBTN136_register_1_17 A[16]=FE_OFN5520_register_1__16
+ A[15]=FE_OFN5521_register_1__15 A[14]=FE_DBTN135_register_1_14
+ A[13]=FE_OFN5523_register_1__13 A[12]=FE_DBTN134_register_1_12
+ A[11]=FE_UNCONNECTEDZ_74 A[10]=FE_DBTN133_register_1_10
+ A[9]=FE_OFN5524_register_1__9 A[8]=FE_DBTN132_register_1_8
+ A[7]=FE_OFN5526_register_1__7 A[6]=FE_OFN6021_register_1__6
+ A[5]=FE_DBTN131_register_1_5 A[4]=FE_OFN5527_register_1__4
+ A[3]=FE_OFN5528_register_1__3 A[2]=N1145 A[1]=FE_DBTN22_n5504
+ A[0]=FE_DBTN9_N1143 B[19]=register[0][19] B[18]=FE_OFN5846_register_0__18
+ B[17]=FE_UNCONNECTEDZ_75 B[16]=register[0][16] B[15]=n6772
+ B[14]=FE_OFN6049_register_0__14 B[13]=FE_OFN5790_register_0__13
+ B[12]=FE_OFN5518_register_0__12 B[11]=FE_OFN6019_register_0__11
+ B[10]=register[0][10] B[9]=FE_OFN5895_register_0__9
+ B[8]=FE_DBTN140_register_0_8 B[7]=FE_DBTN139_register_0_7
+ B[6]=FE_OFN5914_register_0__6 B[5]=register[0][5] B[4]=register[0][4]
+ B[3]=FE_OFN5761_register_0__3 B[2]=FE_OFN6132_n5113 B[1]=register[0][1]
+ B[0]=FE_DBTN1180_N1618 GE_LT_GT_LE=N14471 n5504=n5504
+ _register_1_11=FE_OFN6002_register_1__11 n4988=n4988
+ _register_0_17=FE_OFN5517_register_0__17 p1=FE_DBTN130_register_1_3
+ p2=FE_DBTN137_register_0_3 FE_OFN93_register_1__6=FE_OFN6022_register_1__6
+ FE_OFN5901_register_0__12=FE_OFN5901_register_0__12
Xr2274 CONV_DW01_inc_1_DW01_inc_2 $PINS A[12]=c_cnt[12] A[11]=c_cnt[11]
+ A[10]=N14817 A[9]=N14816 A[8]=N14815 A[7]=N14814 A[6]=N14813 A[5]=N14812
+ A[4]=N14811 A[3]=N14810 A[2]=N14809 A[1]=N14808 A[0]=N14807 SUM[12]=N14313
+ SUM[11]=N14312 SUM[10]=N14311 SUM[9]=N14310 SUM[8]=N14309 SUM[7]=N14308
+ SUM[6]=N14307 SUM[5]=N14306 SUM[4]=N14305 SUM[3]=N14304 SUM[2]=N14303
+ SUM[1]=N14302 SUM[0]=N14301
Xr2267 CONV_DW01_inc_2_DW01_inc_3 $PINS A[12]=a_cnt[12]
+ A[11]=FE_OFN5604_a_cnt_11 A[10]=FE_OFN5605_a_cnt_10 A[9]=FE_OFN5606_a_cnt_9
+ A[8]=FE_OFN5607_a_cnt_8 A[7]=FE_OFN5608_a_cnt_7 A[6]=FE_OFN5609_a_cnt_6
+ A[5]=FE_OFN5599_N8549 A[4]=FE_OFN5598_N8548 A[3]=FE_OFN5597_N8547
+ A[2]=FE_OFN5596_N8546 A[1]=N8545 A[0]=FE_OFN5594_N8543 SUM[12]=n44 SUM[11]=n45
+ SUM[10]=n46 SUM[9]=n47 SUM[8]=n48 SUM[7]=n49 SUM[6]=n50 SUM[5]=n51 SUM[4]=n52
+ SUM[3]=n53 SUM[2]=n54 SUM[1]=n55 SUM[0]=n56 p1=FE_DBTN24_N8543
Xr2266 CONV_DW01_inc_3_DW01_inc_4 $PINS A[19]=CMF1[35] A[18]=CMF1[34]
+ A[17]=CMF1[33] A[16]=CMF1[32] A[15]=CMF1[31] A[14]=CMF1[30] A[13]=CMF1[29]
+ A[12]=CMF1[28] A[11]=CMF1[27] A[10]=CMF1[26] A[9]=CMF1[25] A[8]=CMF1[24]
+ A[7]=CMF1[23] A[6]=CMF1[22] A[5]=CMF1[21] A[4]=CMF1[20] A[3]=CMF1[19]
+ A[2]=CMF1[18] A[1]=CMF1[17] A[0]=CMF1[16] SUM[19]=n57 SUM[18]=n58 SUM[17]=n59
+ SUM[16]=n60 SUM[15]=n61 SUM[14]=n62 SUM[13]=n63 SUM[12]=n64 SUM[11]=n65
+ SUM[10]=n66 SUM[9]=n67 SUM[8]=n68 SUM[7]=n69 SUM[6]=n70 SUM[5]=n71 SUM[4]=n72
+ SUM[3]=n73 SUM[2]=n74 SUM[1]=n75 SUM[0]=n76
Xr2265 CONV_DW01_inc_4_DW01_inc_5 $PINS A[19]=n5117 A[18]=n5118 A[17]=n5112
+ A[16]=n5111 A[15]=CMF0[31] A[14]=CMF0[30] A[13]=CMF0[29] A[12]=CMF0[28]
+ A[11]=CMF0[27] A[10]=CMF0[26] A[9]=CMF0[25] A[8]=CMF0[24] A[7]=CMF0[23]
+ A[6]=CMF0[22] A[5]=CMF0[21] A[4]=CMF0[20] A[3]=CMF0[19] A[2]=CMF0[18]
+ A[1]=CMF0[17] A[0]=CMF0[16] SUM[19]=n77 SUM[18]=n78 SUM[17]=n79 SUM[16]=n80
+ SUM[15]=n81 SUM[14]=n82 SUM[13]=n83 SUM[12]=n84 SUM[11]=n85 SUM[10]=n86
+ SUM[9]=n87 SUM[8]=n88 SUM[7]=n89 SUM[6]=n90 SUM[5]=n91 SUM[4]=n92 SUM[3]=n93
+ SUM[2]=n94 SUM[1]=n95 SUM[0]=FE_UNCONNECTEDZ_76
Xr2229 CONV_DW_mult_uns_20 $PINS a[19]=register[2][19]
+ a[18]=FE_OFN5530_register_2__18 a[17]=FE_OFN5531_register_2__17
+ a[16]=FE_OFN5532_register_2__16 a[15]=FE_OFN5533_register_2__15
+ a[14]=FE_OFN5534_register_2__14 a[13]=FE_OFN5535_register_2__13
+ a[12]=FE_DBTN122_register_2_12 a[11]=FE_OFN5537_register_2__11
+ a[10]=FE_UNCONNECTEDZ_77 a[9]=FE_OFN5539_register_2__9
+ a[8]=FE_OFN5751_register_2__8 a[7]=FE_DBTN118_register_2_7
+ a[6]=FE_OFN5542_register_2__6 a[5]=FE_OFN6038_register_2__5
+ a[4]=FE_OFN5543_register_2__4 a[3]=register[2][3] a[2]=n5215
+ a[1]=register[2][1] a[0]=N15861 product[34]=N601 product[33]=N600
+ product[32]=N599 product[31]=N598 product[30]=N597 product[29]=N596
+ product[28]=N595 product[27]=N594 product[26]=N593 product[25]=N592
+ product[24]=N591 product[23]=N590 product[22]=N589 product[21]=N588
+ product[20]=N587 product[19]=N586 product[18]=N585 product[17]=N584
+ product[16]=N583 product[15]=N582 product[14]=N581 product[13]=N580
+ product[12]=N579 product[11]=N578 product[10]=N577 product[9]=N576
+ product[8]=N575 product[7]=N574 product[6]=N573 product[5]=N572 product[4]=N571
+ product[3]=N570 product[2]=N569 product[1]=N568 product[0]=FE_UNCONNECTEDZ_78
+ n5383=FE_OFN370_register_2__10 _register_2_10=FE_OFN5538_register_2__10
+ p1=FE_OFN5883_N567 p2=FE_OFN5544_register_2__1 p3=FE_OFN5767_register_2__4
+ p4=FE_DBTN116_register_2_5 p5=FE_OFN5787_register_2__6
+ p6=FE_OFN5541_register_2__7 p7=FE_OFN5753_register_2__8
+ p8=FE_OFN602_register_2__9 p9=FE_OFN5818_register_2__11
+ p10=FE_OFN5536_register_2__12 p11=FE_DBTN1157_register_2_13
+ p12=FE_DBTN1156_register_2_14 p13=FE_OFN271_register_2__15
+ p14=FE_DBTN126_register_2_16 p15=FE_DBTN127_register_2_17
+ p16=FE_OFN312_register_2__18 p17=FE_OFN5529_register_2__19
+ FE_OFN12_register_2__1=FE_DBTN1181_register_2_1 FE_OFN33_N567=N567
+ FE_OFN44_n5215=n5215 p18=FE_DBTN1175_register_2_19
+ FE_OFN67_register_2__8=FE_OFN5755_register_2__8
+ FE_OFN72_register_2__14=FE_OFN5779_register_2__14
+ FE_OFN74_register_2__6=FE_OFN5789_register_2__6
+ FE_OFN77_register_2__5=FE_OFN5842_register_2__5
Xr2259 CONV_DW_mult_uns_29 $PINS a[19]=FE_OFN5529_register_2__19
+ a[18]=FE_OFN312_register_2__18 a[17]=FE_DBTN127_register_2_17
+ a[16]=FE_OFN5532_register_2__16 a[15]=FE_OFN5533_register_2__15
+ a[14]=FE_OFN5534_register_2__14 a[13]=FE_OFN5535_register_2__13
+ a[12]=FE_DBTN122_register_2_12 a[11]=FE_OFN5537_register_2__11
+ a[10]=FE_UNCONNECTEDZ_79 a[9]=FE_OFN5539_register_2__9
+ a[8]=FE_OFN5540_register_2__8 a[7]=FE_DBTN118_register_2_7
+ a[6]=FE_OFN5787_register_2__6 a[5]=register[2][5] a[4]=FE_OFN5543_register_2__4
+ a[3]=n5219 a[2]=n5216 a[1]=FE_OFN5544_register_2__1 a[0]=FE_OFN5883_N567
+ product[33]=N1617 product[32]=N1616 product[31]=N1615 product[30]=N1614
+ product[29]=N1613 product[28]=N1612 product[27]=N1611 product[26]=N1610
+ product[25]=N1609 product[24]=N1608 product[23]=N1607 product[22]=N1606
+ product[21]=N1605 product[20]=N1604 product[19]=N1603 product[18]=N1602
+ product[17]=N1601 product[16]=N1600 product[15]=N1599 product[14]=N1598
+ product[13]=N1597 product[12]=N1596 product[11]=N1595 product[10]=N1594
+ product[9]=N1593 product[8]=N1592 product[7]=N1591 product[6]=N1590
+ product[5]=N1589 product[4]=N1588 product[3]=N1587 product[2]=N1586
+ product[1]=SYNOPSYS_UNCONNECTED__0 product[0]=SYNOPSYS_UNCONNECTED__1
+ n5475=n5475 n5214=n5214 n5383=FE_OFN370_register_2__10
+ _register_2_10=FE_OFN5538_register_2__10 p1=N15861 p2=FE_DBTN1181_register_2_1
+ p3=FE_OFN5767_register_2__4 p4=FE_DBTN116_register_2_5
+ p6=FE_OFN5541_register_2__7 p7=register[2][8] p8=FE_OFN602_register_2__9
+ p9=FE_OFN5818_register_2__11 p10=FE_OFN5536_register_2__12
+ p11=FE_DBTN1157_register_2_13 p12=FE_DBTN1156_register_2_14
+ p13=FE_OFN271_register_2__15 p14=FE_DBTN126_register_2_16
+ p15=FE_OFN5531_register_2__17 p16=register[2][18] p17=register[2][19]
+ FE_OFN2_register_2__4=FE_DBTN1155_register_2_4
+ FE_OFN4_register_2__8=FE_OFN5755_register_2__8
+ FE_OFN3_register_2__8=FE_OFN5753_register_2__8
+ FE_OFN42_register_2__6=FE_OFN5789_register_2__6
+ FE_OFN48_register_2__5=FE_OFN5842_register_2__5
+ FE_OFN51_register_2__1=FE_DBTN1181_register_2_1
+ FE_OFN312_register_2__18=FE_OFN5530_register_2__18
+ p18=FE_DBTN1175_register_2_19 FE_OFN71_register_2__14=FE_OFN5779_register_2__14
+ FE_OFN73_register_2__10=FE_OFN5781_register_2__10
+ FE_OFN79_register_2__18=FE_OFN5870_register_2__18
Xr2247 CONV_DW_mult_uns_25 $PINS a[19]=FE_DBTN1162_register_3_19
+ a[18]=FE_DBTN112_register_3_18 a[17]=register[3][17]
+ a[16]=FE_OFN75_register_3__16 a[15]=register[3][15] a[14]=register[3][14]
+ a[13]=n5108 a[12]=register[3][12] a[11]=register[3][11]
+ a[10]=FE_DBTN105_register_3_10 a[9]=n5102 a[8]=FE_OFN5593_N612
+ a[7]=FE_OFN89_N611 a[6]=FE_DBTN29_N610 a[5]=N609 a[4]=FE_OFN5920_N608
+ a[3]=FE_OFN5589_N607 a[2]=FE_OFN5588_N606 a[1]=FE_OFN6039_N1177
+ a[0]=FE_OFN5775_n5319 product[34]=N1210 product[33]=N1209 product[32]=N1208
+ product[31]=N1207 product[30]=N1206 product[29]=N1205 product[28]=N1204
+ product[27]=N1203 product[26]=N1202 product[25]=N1201 product[24]=N1200
+ product[23]=N1199 product[22]=N1198 product[21]=N1197 product[20]=N1196
+ product[19]=N1195 product[18]=N1194 product[17]=N1193 product[16]=N1192
+ product[15]=N1191 product[14]=N1190 product[13]=N1189 product[12]=N1188
+ product[11]=N1187 product[10]=N1186 product[9]=N1185 product[8]=N1184
+ product[7]=N1183 product[6]=N1182 product[5]=N1181 product[4]=N1180
+ product[3]=N1179 product[2]=N1178 product[1]=FE_UNCONNECTEDZ_80
+ product[0]=N1176 n5107=n5107 p1=FE_DBTN10_N1176 p2=FE_DBTN11_N1177
+ p3=FE_OFN354_N612 p5=FE_OFN5591_N610 p6=FE_DBTN30_N609 p7=FE_OFN5590_N608
+ p8=FE_DBTN32_N607 p9=FE_OFN349_N606 p10=FE_OFN5549_register_3__10
+ p11=FE_OFN5548_register_3__11 p12=FE_DBTN1171_register_3_12
+ p14=FE_OFN5878_register_3__15 p15=FE_OFN75_register_3__16
+ p17=FE_DBTN112_register_3_18 p18=register[3][19]
+ _register_3_16=FE_OFN5546_register_3__16 N611=FE_OFN5592_N611
+ _register_3_18=FE_OFN5545_register_3__18 p19=FE_OFN5547_register_3__14
+ p20=FE_OFN5707_register_3__17 p21=FE_DBTN1171_register_3_12
+ p22=FE_DBTN1184_register_3_11
Xr2227 CONV_DW_mult_uns_24 $PINS a[19]=FE_OFN5519_register_1__19 a[18]=n5106
+ a[17]=FE_OFN6029_register_1__17 a[16]=FE_OFN5520_register_1__16
+ a[15]=FE_OFN5521_register_1__15 a[14]=FE_OFN5522_register_1__14
+ a[13]=FE_OFN5523_register_1__13 a[12]=FE_OFN5997_register_1__12
+ a[11]=FE_OFN6002_register_1__11 a[10]=FE_OFN6003_register_1__10
+ a[9]=FE_OFN5524_register_1__9 a[8]=FE_OFN5525_register_1__8
+ a[7]=FE_OFN5526_register_1__7 a[6]=FE_OFN6021_register_1__6
+ a[5]=FE_OFN6015_register_1__5 a[4]=FE_OFN5527_register_1__4
+ a[3]=FE_OFN5528_register_1__3 a[2]=n5222 a[1]=FE_DBTN22_n5504
+ a[0]=FE_OFN5998_register_1__0 product[35]=N530 product[34]=N529
+ product[33]=N528 product[32]=N527 product[31]=N526 product[30]=N525
+ product[29]=N524 product[28]=N523 product[27]=N522 product[26]=N521
+ product[25]=N520 product[24]=N519 product[23]=N518 product[22]=N517
+ product[21]=N516 product[20]=N515 product[19]=N514 product[18]=N513
+ product[17]=N512 product[16]=N511 product[15]=N510 product[14]=N509
+ product[13]=N508 product[12]=N507 product[11]=N506 product[10]=N505
+ product[9]=N504 product[8]=N503 product[7]=N502 product[6]=N501 product[5]=N500
+ product[4]=N499 product[3]=N498 product[2]=N497 product[1]=N496 product[0]=N495
+ n5104=n5104 n4988=n4988 FE_OFN49_register_1__4=register[1][4]
+ FE_OFN56_register_1__13=register[1][13]
+ FE_OFN94_register_1__6=FE_OFN6022_register_1__6
Xr2249 CONV_DW_mult_uns_34 $PINS a[19]=FE_OFN5550_register_4__19
+ a[18]=FE_DBTN103_register_4_18 a[17]=FE_OFN6069_n6728 a[16]=FE_UNCONNECTEDZ_81
+ a[15]=register[4][15] a[14]=FE_UNCONNECTEDZ_82 a[13]=FE_OFN309_register_4__13
+ a[12]=FE_DBTN98_register_4_12 a[11]=FE_UNCONNECTEDZ_83 a[10]=FE_UNCONNECTEDZ_84
+ a[9]=FE_OFN5555_register_4__9 a[8]=FE_UNCONNECTEDZ_85
+ a[7]=FE_OCPN6212_register_4__7 a[6]=register[4][6]
+ a[5]=FE_OFN5826_register_4__5 a[4]=register[4][4] a[3]=n4938
+ a[2]=FE_DBTN14_N1254 a[1]=FE_OFN5601_N1253 a[0]=register[4][0]
+ product[33]=N1280 product[32]=N1279 product[31]=N1278 product[30]=N1277
+ product[29]=N1276 product[28]=N1275 product[27]=N1274 product[26]=N1273
+ product[25]=N1272 product[24]=N1271 product[23]=N1270 product[22]=N1269
+ product[21]=N1268 product[20]=N1267 product[19]=N1266 product[18]=N1265
+ product[17]=N1264 product[16]=N1263 product[15]=N1262 product[14]=N1261
+ product[13]=N1260 product[12]=N1259 product[11]=N1258 product[10]=N1257
+ product[9]=N1256 product[8]=N1255 product[7]=FE_UNCONNECTEDZ_86
+ product[6]=FE_UNCONNECTEDZ_87 product[5]=N1252
+ product[4]=SYNOPSYS_UNCONNECTED__2 product[3]=SYNOPSYS_UNCONNECTED__3
+ product[2]=SYNOPSYS_UNCONNECTED__4 product[1]=SYNOPSYS_UNCONNECTED__5
+ product[0]=SYNOPSYS_UNCONNECTED__6 p1=FE_DBTN0_n6728 p2=FE_DBTN13_N1253
+ p3=FE_OFN5557_register_4__2 p4=FE_DBTN90_register_4_4 p5=FE_DBTN91_register_4_5
+ p6=FE_DBTN1174_register_4_6 p7=FE_DBTN1173_register_4_7
+ p8=FE_OFN5905_register_4__8 p9=FE_OFN335_register_4__9
+ p10=FE_OFN5874_register_4__10 p11=FE_OFN5553_register_4__11
+ p12=FE_OFN5824_register_4__12 p13=register[4][13] p14=FE_OFN79_register_4__14
+ p15=FE_OFN5712_register_4__15 p16=FE_OFN5551_register_4__16
+ p17=FE_OFN5703_register_4__18 p18=FE_DBTN1177_register_4_19
+ _register_4_14=FE_OFN5552_register_4__14 _register_4_8=FE_OFN5556_register_4__8
+ _register_4_11=FE_OFN5865_register_4__11
+ _register_4_10=FE_OFN5554_register_4__10 _register_4_16=FE_OFN78_register_4__16
+ FE_OFN76_register_4__12=FE_OFN5824_register_4__12 FE_OFN97_n6728=FE_DBTN0_n6728
Xr2251 CONV_DW01_add_27 $PINS A[34]=FE_UNCONNECTEDZ_88 A[33]=N1280 A[32]=N1279
+ A[31]=N1278 A[30]=N1277 A[29]=N1276 A[28]=N1275 A[27]=N1274 A[26]=N1273
+ A[25]=N1272 A[24]=N1271 A[23]=N1270 A[22]=N1269 A[21]=N1268 A[20]=N1267
+ A[19]=N1266 A[18]=N1265 A[17]=N1264 A[16]=N1263 A[15]=N1262 A[14]=N1261
+ A[13]=N1260 A[12]=N1259 A[11]=N1258 A[10]=N1257 A[9]=N1256 A[8]=N1255
+ A[7]=FE_OFN5557_register_4__2 A[6]=FE_OFN5601_N1253 A[5]=register[4][0]
+ A[4]=FE_UNCONNECTEDZ_89 A[3]=FE_UNCONNECTEDZ_90 A[2]=FE_UNCONNECTEDZ_91
+ A[1]=FE_UNCONNECTEDZ_92 A[0]=FE_UNCONNECTEDZ_93 B[34]=FE_UNCONNECTEDZ_94
+ B[33]=N1314 B[32]=N1313 B[31]=N1312 B[30]=N1311 B[29]=N1310 B[28]=N1309
+ B[27]=N1308 B[26]=N1307 B[25]=N1306 B[24]=N1305 B[23]=N1304 B[22]=N1303
+ B[21]=N1302 B[20]=N1301 B[19]=N1300 B[18]=N1299 B[17]=N1298 B[16]=N1297
+ B[15]=N1296 B[14]=N1295 B[13]=N1294 B[12]=N1293 B[11]=N1292 B[10]=N1291
+ B[9]=N1290 B[8]=N1289 B[7]=N1288 B[6]=N1287 B[5]=N1286 B[4]=N1285 B[3]=N1284
+ B[2]=N1283 B[1]=N1282 B[0]=N1281 SUM[34]=N1349 SUM[33]=N1348 SUM[32]=N1347
+ SUM[31]=N1346 SUM[30]=N1345 SUM[29]=N1344 SUM[28]=N1343 SUM[27]=N1342
+ SUM[26]=N1341 SUM[25]=N1340 SUM[24]=N1339 SUM[23]=N1338 SUM[22]=N1337
+ SUM[21]=N1336 SUM[20]=N1335 SUM[19]=N1334 SUM[18]=N1333 SUM[17]=N1332
+ SUM[16]=N1331 SUM[15]=N1330 SUM[14]=N1329 SUM[13]=N1328 SUM[12]=N1327
+ SUM[11]=N1326 SUM[10]=N1325 SUM[9]=N1324 SUM[8]=N1323 SUM[7]=N1322 SUM[6]=N1321
+ SUM[5]=N1320 SUM[4]=N1319 SUM[3]=N1318 SUM[2]=N1317 SUM[1]=FE_UNCONNECTEDZ_95
+ SUM[0]=FE_UNCONNECTEDZ_96
Xr2253 CONV_DW_mult_uns_45 $PINS a[19]=register[6][19]
+ a[18]=FE_OFN5567_register_6__18 a[17]=register[6][17] a[16]=register[6][16]
+ a[15]=FE_OFN5984_register_6__15 a[14]=register[6][14]
+ a[13]=FE_OFN5989_register_6__13 a[12]=register[6][12]
+ a[11]=FE_DBTN69_register_6_11 a[10]=register[6][10]
+ a[9]=FE_OFN5569_register_6__9 a[8]=FE_OFN5570_register_6__8
+ a[7]=FE_OFN5571_register_6__7 a[6]=FE_DBTN64_register_6_6
+ a[5]=FE_OFN5573_register_6__5 a[4]=FE_OFN5574_register_6__4
+ a[3]=FE_DBTN1183_register_6_3 a[2]=n4963 a[1]=N872 a[0]=n5321 product[33]=N1419
+ product[32]=N1418 product[31]=N1417 product[30]=N1416 product[29]=N1415
+ product[28]=N1414 product[27]=N1413 product[26]=N1412 product[25]=N1411
+ product[24]=N1410 product[23]=N1409 product[22]=N1408 product[21]=N1407
+ product[20]=N1406 product[19]=N1405 product[18]=N1404 product[17]=N1403
+ product[16]=N1402 product[15]=N1401 product[14]=N1400 product[13]=N1399
+ product[12]=N1398 product[11]=N1397 product[10]=N1396 product[9]=N1395
+ product[8]=N1394 product[7]=N1393 product[6]=N1392 product[5]=N1391
+ product[4]=N1390 product[3]=N1389 product[2]=N1388 product[1]=N1387
+ product[0]=FE_UNCONNECTEDZ_97 n4973=FE_OFN5600_N872 p1=N1386 p2=n4963
+ p3=FE_OFN5575_register_6__3 p4=FE_DBTN62_register_6_4 p5=FE_DBTN63_register_6_5
+ p6=FE_OFN5572_register_6__6 p7=FE_OFN390_register_6__7
+ p9=FE_OFN616_register_6__9 p10=FE_DBTN68_register_6_10
+ p11=FE_OFN5568_register_6__11 p12=FE_DBTN70_register_6_12
+ p13=FE_DBTN71_register_6_13 p14=FE_DBTN72_register_6_14
+ p15=FE_DBTN73_register_6_15 p16=FE_DBTN74_register_6_16
+ p17=FE_DBTN75_register_6_17 p18=FE_OFN5757_register_6__18
+ p19=FE_DBTN77_register_6_19 FE_OFN1_N1386=N1455 p20=FE_DBTN1158_n4963
+ p21=FE_DBTN1179_N872 p22=FE_DBTN1183_register_6_3
+ FE_OFN63_register_6__19=FE_DBTN77_register_6_19
+ FE_OFN90_register_6__17=register[6][17]
+ FE_OFN5830_register_6__8=FE_OFN5830_register_6__8
Xr2254 CONV_DW_mult_uns_46 $PINS a[19]=FE_OFN5582_register_8__19
+ a[18]=register[8][18] a[17]=FE_DBTN49_register_8_17
+ a[16]=FE_OFN5713_register_8__16 a[15]=FE_OFN5993_register_8__15
+ a[14]=FE_OFN5584_register_8__14 a[13]=FE_OFN5717_register_8__13
+ a[12]=FE_OFN5585_register_8__12 a[11]=FE_OFN5742_register_8__11
+ a[10]=FE_OFN5666_register_8__10 a[9]=FE_OFN5586_register_8__9
+ a[8]=FE_DBTN1165_register_8_8 a[7]=FE_OFN6026_register_8__7
+ a[6]=FE_DBTN38_register_8_6 a[5]=FE_OFN5719_register_8__5
+ a[4]=FE_OFN6018_register_8__4 a[3]=register[8][3] a[2]=register[8][2]
+ a[1]=N1424 a[0]=FE_DBTN8_N1034 product[34]=N1454 product[33]=N1453
+ product[32]=N1452 product[31]=N1451 product[30]=N1450 product[29]=N1449
+ product[28]=N1448 product[27]=N1447 product[26]=N1446 product[25]=N1445
+ product[24]=N1444 product[23]=N1443 product[22]=N1442 product[21]=N1441
+ product[20]=N1440 product[19]=N1439 product[18]=N1438 product[17]=N1437
+ product[16]=N1436 product[15]=N1435 product[14]=N1434 product[13]=N1433
+ product[12]=N1432 product[11]=N1431 product[10]=N1430 product[9]=N1429
+ product[8]=N1428 product[7]=N1427 product[6]=N1426 product[5]=N1425
+ product[4]=FE_UNCONNECTEDZ_98 product[3]=FE_UNCONNECTEDZ_99
+ product[2]=SYNOPSYS_UNCONNECTED__7 product[1]=SYNOPSYS_UNCONNECTED__8
+ product[0]=SYNOPSYS_UNCONNECTED__9 p1=FE_DBTN8_N1034 p2=FE_OFN5953_n5323
+ p3=FE_DBTN34_register_8_2 p4=FE_DBTN1169_register_8_3
+ p5=FE_DBTN1164_register_8_4 p6=FE_DBTN1163_register_8_5
+ p8=FE_DBTN39_register_8_7 p9=FE_DBTN1165_register_8_8 p10=register[8][9]
+ p11=FE_DBTN1172_register_8_10 p12=FE_OFN6036_register_8__11 p13=register[8][12]
+ p14=FE_DBTN45_register_8_13 p15=FE_OFN304_register_8__14
+ p16=FE_DBTN1166_register_8_15 p17=FE_OFN306_register_8__16
+ p18=FE_OFN5691_register_8__17 p19=FE_OFN5822_register_8__18
+ p20=FE_DBTN1176_register_8_19 FE_OFN5_register_8__12=FE_OFN605_register_8__12
+ FE_OFN8_register_8__15=FE_DBTN1166_register_8_15
+ FE_OFN9_register_8__3=FE_DBTN1169_register_8_3
+ FE_OFN15_register_8__9=FE_OFN5793_register_8__9 FE_OFN19_N1034=FE_OFN5730_N999
+ FE_OFN17_N1034=FE_OFN6005_N999 FE_OFN21_register_8__14=register[8][14]
+ FE_OFN23_register_8__16=FE_OFN5979_register_8__16
+ FE_OFN39_register_8__19=FE_DBTN1176_register_8_19
+ FE_OFN47_register_8__18=FE_OFN5583_register_8__18
+ FE_OFN52_register_8__12=FE_OFN5819_register_8__12
+ _register_8_6=FE_OFN5587_register_8__6 p21=FE_DBTN1163_register_8_5
+ p22=FE_DBTN1164_register_8_4 p23=FE_OFN5731_register_8__8
+ p24=FE_DBTN1172_register_8_10 FE_OFN61_n5323=FE_OFN5648_n5323
+ FE_OFN68_register_8__7=FE_OFN5771_register_8__7
+ FE_OFN69_register_8__2=FE_OFN5777_register_8__2 FE_OFN85_N1424=N1424
+ FE_OFN86_register_8__16=FE_OFN5980_register_8__16
+ FE_OFN89_register_8__15=FE_OFN5993_register_8__15
+ FE_OFN91_register_8__3=FE_OFN6011_register_8__3
+ FE_OFN95_n=FE_OFN5587_register_8__6 FE_OFN101_n=FE_OFN5586_register_8__9
Xr2255 CONV_DW01_add_40 $PINS A[35]=FE_UNCONNECTEDZ_100
+ A[34]=FE_UNCONNECTEDZ_101 A[33]=N1419 A[32]=N1418 A[31]=N1417 A[30]=N1416
+ A[29]=N1415 A[28]=N1414 A[27]=N1413 A[26]=N1412 A[25]=N1411 A[24]=N1410
+ A[23]=N1409 A[22]=N1408 A[21]=N1407 A[20]=N1406 A[19]=N1405 A[18]=N1404
+ A[17]=N1403 A[16]=N1402 A[15]=N1401 A[14]=N1400 A[13]=N1399 A[12]=N1398
+ A[11]=N1397 A[10]=N1396 A[9]=N1395 A[8]=N1394 A[7]=N1393 A[6]=N1392 A[5]=N1391
+ A[4]=N1390 A[3]=N1389 A[2]=N1388 A[1]=N1387 A[0]=N1386
+ B[35]=FE_UNCONNECTEDZ_102 B[34]=N1454 B[33]=N1453 B[32]=N1452 B[31]=N1451
+ B[30]=N1450 B[29]=N1449 B[28]=N1448 B[27]=N1447 B[26]=N1446 B[25]=N1445
+ B[24]=N1444 B[23]=N1443 B[22]=N1442 B[21]=N1441 B[20]=N1440 B[19]=N1439
+ B[18]=N1438 B[17]=N1437 B[16]=N1436 B[15]=N1435 B[14]=N1434 B[13]=N1433
+ B[12]=N1432 B[11]=N1431 B[10]=N1430 B[9]=N1429 B[8]=N1428 B[7]=N1427 B[6]=N1426
+ B[5]=N1425 B[4]=FE_OFN5953_n5323 B[3]=FE_OFN5728_N999 B[2]=FE_UNCONNECTEDZ_103
+ B[1]=FE_UNCONNECTEDZ_104 B[0]=FE_UNCONNECTEDZ_105 SUM[35]=N1490 SUM[34]=N1489
+ SUM[33]=N1488 SUM[32]=N1487 SUM[31]=N1486 SUM[30]=N1485 SUM[29]=N1484
+ SUM[28]=N1483 SUM[27]=N1482 SUM[26]=N1481 SUM[25]=N1480 SUM[24]=N1479
+ SUM[23]=N1478 SUM[22]=N1477 SUM[21]=N1476 SUM[20]=N1475 SUM[19]=N1474
+ SUM[18]=N1473 SUM[17]=N1472 SUM[16]=N1471 SUM[15]=N1470 SUM[14]=N1469
+ SUM[13]=N1468 SUM[12]=N1467 SUM[11]=N1466 SUM[10]=N1465 SUM[9]=N1464
+ SUM[8]=N1463 SUM[7]=N1462 SUM[6]=N1461 SUM[5]=N1460 SUM[4]=N1459 SUM[3]=N1458
+ SUM[2]=N1457 SUM[1]=N1456 SUM[0]=FE_UNCONNECTEDZ_106
Xr2238 CONV_DW_mult_uns_47 $PINS a[19]=register[6][19] a[18]=register[6][18]
+ a[17]=register[6][17] a[16]=register[6][16] a[15]=FE_OFN5984_register_6__15
+ a[14]=register[6][14] a[13]=FE_OFN5989_register_6__13 a[12]=register[6][12]
+ a[11]=FE_OFN5568_register_6__11 a[10]=register[6][10]
+ a[9]=FE_OFN5569_register_6__9 a[8]=FE_OFN5570_register_6__8
+ a[7]=FE_OFN5571_register_6__7 a[6]=FE_OFN5572_register_6__6
+ a[5]=FE_DBTN63_register_6_5 a[4]=FE_DBTN62_register_6_4
+ a[3]=FE_OFN5575_register_6__3 a[2]=n4963 a[1]=FE_OFN5600_N872 a[0]=n5321
+ product[34]=N905 product[33]=N904 product[32]=N903 product[31]=N902
+ product[30]=N901 product[29]=N900 product[28]=N899 product[27]=N898
+ product[26]=N897 product[25]=N896 product[24]=N895 product[23]=N894
+ product[22]=N893 product[21]=N892 product[20]=N891 product[19]=N890
+ product[18]=N889 product[17]=N888 product[16]=N887 product[15]=N886
+ product[14]=N885 product[13]=N884 product[12]=N883 product[11]=N882
+ product[10]=N881 product[9]=N880 product[8]=N879 product[7]=N878
+ product[6]=N877 product[5]=N876 product[4]=N875 product[3]=N874 product[2]=N873
+ product[1]=FE_UNCONNECTEDZ_107 product[0]=N871 p1=FE_DBTN17_N13861
+ p2=FE_DBTN17_N1386 p3=n4963 p4=FE_DBTN77_register_6_19
+ FE_OFN502_register_6__18=FE_OFN5757_register_6__18
Xr2233 CONV_DW_mult_uns_48 $PINS a[19]=FE_DBTN1177_register_4_19
+ a[18]=FE_OFN5703_register_4__18 a[17]=FE_DBTN0_n6728 a[16]=FE_UNCONNECTEDZ_108
+ a[15]=register[4][15] a[14]=FE_UNCONNECTEDZ_109 a[13]=FE_OFN309_register_4__13
+ a[12]=FE_OFN6068_register_4__12 a[11]=FE_UNCONNECTEDZ_110
+ a[10]=FE_DBTN96_register_4_10 a[9]=FE_OFN335_register_4__9
+ a[8]=FE_UNCONNECTEDZ_111 a[7]=register[4][7] a[6]=FE_DBTN1174_register_4_6
+ a[5]=FE_OFN5826_register_4__5 a[4]=FE_DBTN90_register_4_4 a[3]=n4939
+ a[2]=FE_OFN5557_register_4__2 a[1]=FE_OFN5601_N1253 a[0]=N707 product[34]=N741
+ product[33]=N740 product[32]=N739 product[31]=N738 product[30]=N737
+ product[29]=N736 product[28]=N735 product[27]=N734 product[26]=N733
+ product[25]=N732 product[24]=N731 product[23]=N730 product[22]=N729
+ product[21]=N728 product[20]=N727 product[19]=N726 product[18]=N725
+ product[17]=N724 product[16]=N723 product[15]=N722 product[14]=N721
+ product[13]=N720 product[12]=N719 product[11]=N718 product[10]=N717
+ product[9]=N716 product[8]=N715 product[7]=N714 product[6]=N713 product[5]=N712
+ product[4]=N711 product[3]=N710 product[2]=N709 product[1]=N708
+ product[0]=FE_UNCONNECTEDZ_112 n4937=n4939 p1=FE_DBTN0_n6728
+ p2=FE_DBTN12_N12521 p3=FE_DBTN12_N1252 p4=FE_DBTN13_N1253 p5=FE_DBTN14_N1254
+ p6=FE_OFN5814_register_4__4 p7=FE_DBTN91_register_4_5 p8=register[4][6]
+ p9=FE_DBTN1173_register_4_7 p10=FE_DBTN94_register_4_8
+ p11=FE_OFN5839_register_4__9 p13=FE_OFN5865_register_4__11
+ p14=FE_OFN5824_register_4__12 p15=FE_OFN309_register_4__13
+ p16=FE_OFN79_register_4__14 p17=FE_OFN5711_register_4__15
+ p18=FE_OFN78_register_4__16 p19=FE_DBTN103_register_4_18
+ p20=FE_OFN5550_register_4__19 FE_OFN13_register_4__16=FE_OFN5551_register_4__16
+ FE_OFN25_register_4__7=FE_DBTN1173_register_4_7
+ FE_OFN26_register_4__13=FE_OFN309_register_4__13
+ FE_OFN27_register_4__6=FE_DBTN1174_register_4_6
+ FE_OFN35_register_4__9=FE_OFN335_register_4__9
+ FE_OFN34_register_4__9=FE_OFN335_register_4__9
+ FE_OFN41_register_4__14=FE_OFN79_register_4__14
+ FE_OFN594_n4937=FE_OFN5602_n4937 _register_4_14=FE_OFN79_register_4__14
+ _register_4_8=FE_OFN5556_register_4__8 _register_4_11=FE_OFN5553_register_4__11
+ _register_4_10=FE_OFN5554_register_4__10 p21=FE_DBTN1177_register_4_19
+ FE_OFN62_register_4__18=FE_OFN5703_register_4__18
+ FE_OFN78_register_4__11=FE_OFN5553_register_4__11
+ FE_OFN80_register_4__10=FE_OFN5554_register_4__10
+ FE_OFN81_register_4__8=FE_OFN5905_register_4__8
+ FE_OFN92_register_4__7=register[4][7] FE_OFN98_n6728=FE_DBTN0_n6728
+ FE_OFN5865_register_4__11=FE_OFN5865_register_4__11
+ FE_OFN5748_register_4__13=FE_OFN5748_register_4__13
+ FE_OFN5740_register_4__19=FE_OFN5740_register_4__19
+ FE_OFN5745_register_4__14=FE_OFN5745_register_4__14
+ FE_OFN5910_register_4__16=FE_OFN5910_register_4__16
Xr2234 CONV_DW01_sub_19 $PINS B[35]=FE_UNCONNECTEDZ_113 B[34]=N741 B[33]=N740
+ B[32]=N739 B[31]=N738 B[30]=N737 B[29]=N736 B[28]=N735 B[27]=N734 B[26]=N733
+ B[25]=N732 B[24]=N731 B[23]=N730 B[22]=N729 B[21]=N728 B[20]=N727 B[19]=N726
+ B[18]=N725 B[17]=N724 B[16]=N723 B[15]=N722 B[14]=N721 B[13]=N720 B[12]=N719
+ B[11]=N718 B[10]=N717 B[9]=N716 B[8]=N715 B[7]=N714 B[6]=N713 B[5]=N712
+ B[4]=N711 B[3]=N710 B[2]=N709 B[1]=N708 B[0]=N707 DIFF[35]=N777 DIFF[34]=N776
+ DIFF[33]=N775 DIFF[32]=N774 DIFF[31]=N773 DIFF[30]=N772 DIFF[29]=N771
+ DIFF[28]=N770 DIFF[27]=N769 DIFF[26]=N768 DIFF[25]=N767 DIFF[24]=N766
+ DIFF[23]=N765 DIFF[22]=N764 DIFF[21]=N763 DIFF[20]=N762 DIFF[19]=N761
+ DIFF[18]=N760 DIFF[17]=N759 DIFF[16]=N758 DIFF[15]=N757 DIFF[14]=N756
+ DIFF[13]=N755 DIFF[12]=N754 DIFF[11]=N753 DIFF[10]=N752 DIFF[9]=N751
+ DIFF[8]=N750 DIFF[7]=N749 DIFF[6]=N748 DIFF[5]=N747 DIFF[4]=N746 DIFF[3]=N745
+ DIFF[2]=N744 DIFF[1]=N743 DIFF[0]=N742 p1=FE_DBTN12_N12521
Xregister_reg[5][16] SDFFRHQXL $PINS SI=FE_OFN6069_n6728
+ SE=FE_OFN5509_i_SCAN_EN D=n1921 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][16]
Xregister_reg[5][6] SDFFRHQXL $PINS SI=N1281 SE=FE_OFN5509_i_SCAN_EN D=n1911
+ CK=CTS_5 RN=FE_OFN5943_n Q=register[5][6]
Xregister_reg[0][17] SDFFRHQXL $PINS SI=FE_OFN6049_register_0__14
+ SE=FE_OFN5510_i_SCAN_EN D=n1882 CK=CTS_1 RN=FE_DBTN149_i_reset
+ Q=register[0][17]
Xregister_reg[0][16] SDFFRHQX4 $PINS SI=FE_OFN5622_CMF0_2
+ SE=FE_OFN5510_i_SCAN_EN D=n1881 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[0][16]
Xregister_reg[7][10] SDFFRHQXL $PINS SI=FE_OFN5783_register_7__9
+ SE=FE_OFN5515_i_SCAN_EN D=n1793 CK=CTS_2 RN=FE_OFN5945_n Q=register[7][10]
Xregister_reg[6][18] SDFFRHQXL $PINS SI=register[6][19] SE=FE_OFN5513_i_SCAN_EN
+ D=n1816 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[6][18]
Xregister_reg[8][18] SDFFRHQXL $PINS SI=register[8][17] SE=FE_OFN5513_i_SCAN_EN
+ D=n1818 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[8][18]
Xregister_reg[8][14] SDFFRHQXL $PINS SI=register[8][13] SE=FE_OFN5513_i_SCAN_EN
+ D=n1806 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[8][14]
Xregister_reg[5][17] SDFFRHQX2 $PINS SI=FE_DBTN103_register_4_18
+ SE=FE_OFN5509_i_SCAN_EN D=n1922 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][17]
Xregister_reg[7][15] SDFFRHQX2 $PINS SI=n5649 SE=FE_OFN5515_i_SCAN_EN D=n1808
+ CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[7][15]
Xregister_reg[7][5] SDFFRHQXL $PINS SI=CMF1[15] SE=FE_OFN5513_i_SCAN_EN D=n1778
+ CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[7][5]
Xregister_reg[0][18] SDFFRHQXL $PINS SI=FE_DBTN1167_register_0_19
+ SE=FE_OFN5510_i_SCAN_EN D=n1883 CK=CTS_1 RN=FE_DBTN149_i_reset
+ Q=register[0][18]
Xregister_reg[7][16] SDFFRHQXL $PINS SI=register[7][17] SE=FE_OFN5515_i_SCAN_EN
+ D=n1811 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[7][16]
Xregister_reg[1][19] SDFFRHQXL $PINS SI=FE_OFN6038_register_2__5
+ SE=FE_OFN5510_i_SCAN_EN D=n1904 CK=CTS_1 RN=FE_OFN5634_FE_DBTN149_i_reset
+ Q=register[1][19]
Xregister_reg[5][19] SDFFRHQXL $PINS SI=FE_OFN5559_register_5__16
+ SE=FE_OFN5509_i_SCAN_EN D=n1905 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][19]
Xr2241 CONV_DW_mult_uns_23_0 $PINS a[35]=n5256 a[34]=n5256 a[33]=n5256
+ a[32]=n5256 a[31]=n5256 a[30]=n5256 a[29]=n5256 a[28]=n5256 a[27]=n5256
+ a[26]=n5256 a[25]=n5256 a[24]=n5256 a[23]=n5256 a[22]=n5256 a[21]=n5256
+ a[20]=n5256 a[19]=n5318 a[18]=r2240/DIFF[18] a[17]=r2240/DIFF[17] a[16]=n4982
+ a[15]=FE_OFN549_n4975 a[14]=n4931 a[13]=r2240/DIFF[13] a[12]=FE_OFN5405_n4983
+ a[11]=r2240/DIFF[11] a[10]=n4887 a[9]=FE_OFN5416_r2240_DIFF_9
+ a[8]=FE_OFN6060_n4907 a[7]=FE_OFN6141_n a[6]=n4889 a[5]=r2240/DIFF[5]
+ a[4]=r2240/DIFF[4] a[3]=n5244 a[2]=n5243 a[1]=n5269
+ a[0]=FE_OFN5848_FE_DBTN21_N1711 product[49]=SYNOPSYS_UNCONNECTED__10
+ product[48]=SYNOPSYS_UNCONNECTED__11 product[47]=SYNOPSYS_UNCONNECTED__12
+ product[46]=SYNOPSYS_UNCONNECTED__13 product[45]=SYNOPSYS_UNCONNECTED__14
+ product[44]=SYNOPSYS_UNCONNECTED__15 product[43]=SYNOPSYS_UNCONNECTED__16
+ product[42]=SYNOPSYS_UNCONNECTED__17 product[41]=SYNOPSYS_UNCONNECTED__18
+ product[40]=SYNOPSYS_UNCONNECTED__19 product[39]=SYNOPSYS_UNCONNECTED__20
+ product[38]=SYNOPSYS_UNCONNECTED__21 product[37]=SYNOPSYS_UNCONNECTED__22
+ product[36]=SYNOPSYS_UNCONNECTED__23 product[35]=N998 product[34]=N997
+ product[33]=N996 product[32]=N995 product[31]=N994 product[30]=N993
+ product[29]=N992 product[28]=N991 product[27]=N990 product[26]=N989
+ product[25]=N988 product[24]=N987 product[23]=N986 product[22]=N985
+ product[21]=N984 product[20]=N983 product[19]=N982 product[18]=N981
+ product[17]=N980 product[16]=N979 product[15]=N978 product[14]=N977
+ product[13]=N976 product[12]=N975 product[11]=N974 product[10]=N973
+ product[9]=N972 product[8]=N971 product[7]=N970 product[6]=N969 product[5]=N968
+ product[4]=N967 product[3]=N966 product[2]=FE_UNCONNECTEDZ_114
+ product[1]=SYNOPSYS_UNCONNECTED__24 product[0]=SYNOPSYS_UNCONNECTED__25
+ n4908=n5318 n4907=n5314 n4906=FE_OFN6157_n4906 n4905=FE_OFN6150_n4905
+ n6739=n6739 n5280=n4887 n5286=r2240/DIFF[5] p1=N965
+ FE_OFN60_n4983=FE_OFN5405_n4983 N965=FE_OFN5853_FE_DBTN21_N1711 p_2=n4982
+ p_3=n5286 p_4=n4931 FE_OFN84_n=FE_OFN5966_n
+ FE_OFN5855_FE_DBTN21_N1711=FE_OFN5855_FE_DBTN21_N1711
Xr2250 CONV_DW_mult_uns_30_0 $PINS a[19]=FE_OFN5558_register_5__19
+ a[18]=register[5][18] a[17]=register[5][17] a[16]=FE_OFN5559_register_5__16
+ a[15]=FE_OFN5560_register_5__15 a[14]=register[5][14] a[13]=register[5][13]
+ a[12]=FE_OFN5561_register_5__12 a[11]=register[5][11]
+ a[10]=FE_OFN5562_register_5__10 a[9]=FE_OFN5563_register_5__9
+ a[8]=register[5][8] a[7]=FE_OFN5564_register_5__7 a[6]=FE_OFN5565_register_5__6
+ a[5]=register[5][5] a[4]=n5534 a[3]=FE_OFN5743_register_5__3
+ a[2]=FE_OFN5722_register_5__2 a[1]=FE_OFN5804_N1316 a[0]=N1281
+ product[33]=N1314 product[32]=N1313 product[31]=N1312 product[30]=N1311
+ product[29]=N1310 product[28]=N1309 product[27]=N1308 product[26]=N1307
+ product[25]=N1306 product[24]=N1305 product[23]=N1304 product[22]=N1303
+ product[21]=N1302 product[20]=N1301 product[19]=N1300 product[18]=N1299
+ product[17]=N1298 product[16]=N1297 product[15]=N1296 product[14]=N1295
+ product[13]=N1294 product[12]=N1293 product[11]=N1292 product[10]=N1291
+ product[9]=N1290 product[8]=N1289 product[7]=N1288 product[6]=N1287
+ product[5]=N1286 product[4]=N1285 product[3]=N1284 product[2]=N1283
+ product[1]=FE_UNCONNECTEDZ_115 product[0]=FE_UNCONNECTEDZ_116
+ p1=FE_DBTN83_register_5_13 p2=FE_DBTN84_register_5_14
+ p3=FE_DBTN85_register_5_15 p4=FE_DBTN86_register_5_16
+ p5=FE_DBTN87_register_5_17 p6=FE_DBTN88_register_5_18
+ p7=FE_DBTN89_register_5_19 FE_OFN30_register_5__2=register[5][2]
+ FE_OFN31_register_5__9=register[5][9] FE_OFN32_register_5__4=n5534
+ FE_OFN37_N1281=N1281 FE_OFN36_N1281=FE_OCPN6229_N1281
+ FE_OFN50_register_5__8=register[5][8] FE_OFN59_register_5__4=n5534
+ _register_5_4=FE_OFN5721_register_5__4 FE_OFN100_N1281=FE_OCPN6229_N1281
Xr2226 CONV_DW_mult_uns_26_0 $PINS a[19]=register[0][19]
+ a[18]=FE_OFN5516_register_0__18 a[17]=FE_UNCONNECTEDZ_117 a[16]=register[0][16]
+ a[15]=n6772 a[14]=FE_OFN6049_register_0__14 a[13]=register[0][13]
+ a[12]=FE_OFN5901_register_0__12 a[11]=register[0][11] a[10]=register[0][10]
+ a[9]=register[0][9] a[8]=FE_DBTN140_register_0_8 a[7]=FE_DBTN139_register_0_7
+ a[6]=register[0][6] a[5]=register[0][5] a[4]=register[0][4]
+ a[3]=FE_DBTN137_register_0_3 a[2]=FE_OFN6132_n5113 a[1]=register[0][1]
+ a[0]=N1618 product[35]=N494 product[34]=N493 product[33]=N492 product[32]=N491
+ product[31]=N490 product[30]=N489 product[29]=N488 product[28]=N487
+ product[27]=N486 product[26]=N485 product[25]=N484 product[24]=N483
+ product[23]=N482 product[22]=N481 product[21]=N480 product[20]=N479
+ product[19]=N478 product[18]=N477 product[17]=N476 product[16]=N475
+ product[15]=N474 product[14]=N473 product[13]=N472 product[12]=N471
+ product[11]=N470 product[10]=N469 product[9]=N468 product[8]=N467
+ product[7]=N466 product[6]=N465 product[5]=N464 product[4]=N463 product[3]=N462
+ product[2]=N461 product[1]=FE_UNCONNECTEDZ_118
+ product[0]=SYNOPSYS_UNCONNECTED__26 n4996=register[0][17]
+ _register_0_17=FE_OFN5517_register_0__17 p1=FE_DBTN1180_N1618
+ p2=FE_DBTN137_register_0_3 p3=FE_OFN5914_register_0__6
+ p4=FE_OFN5877_register_0__7 p5=FE_OFN5862_register_0__8
+ p6=FE_OFN5895_register_0__9 p7=FE_OFN6019_register_0__11
+ p8=FE_OFN5518_register_0__12 p9=FE_OFN5790_register_0__13
+ p10=FE_DBTN145_register_0_14 p11=FE_DBTN146_register_0_16
+ p12=FE_OFN5846_register_0__18 p13=FE_DBTN1167_register_0_19
+ FE_OFN388_register_0__11=FE_OFN388_register_0__11
+ _register_0_3=FE_OFN5761_register_0__3 p14=FE_DBTN1167_register_0_19
+ p15=FE_DBTN1170_register_0_17 p16=FE_OFN5668_N1618
Xr2228 CONV_DW01_add_6 $PINS A[35]=N494 A[34]=N493 A[33]=N492 A[32]=N491
+ A[31]=N490 A[30]=N489 A[29]=N488 A[28]=N487 A[27]=N486 A[26]=N485 A[25]=N484
+ A[24]=N483 A[23]=N482 A[22]=N481 A[21]=N480 A[20]=N479 A[19]=N478 A[18]=N477
+ A[17]=N476 A[16]=N475 A[15]=N474 A[14]=N473 A[13]=N472 A[12]=N471 A[11]=N470
+ A[10]=N469 A[9]=N468 A[8]=N467 A[7]=N466 A[6]=N465 A[5]=N464 A[4]=N463
+ A[3]=N462 A[2]=N461 A[1]=FE_DBTN1180_N1618 A[0]=FE_UNCONNECTEDZ_119 B[35]=N530
+ B[34]=N529 B[33]=N528 B[32]=N527 B[31]=N526 B[30]=N525 B[29]=N524 B[28]=N523
+ B[27]=N522 B[26]=N521 B[25]=N520 B[24]=N519 B[23]=N518 B[22]=N517 B[21]=N516
+ B[20]=N515 B[19]=N514 B[18]=N513 B[17]=N512 B[16]=N511 B[15]=N510 B[14]=N509
+ B[13]=N508 B[12]=N507 B[11]=N506 B[10]=N505 B[9]=N504 B[8]=N503 B[7]=N502
+ B[6]=N501 B[5]=N500 B[4]=N499 B[3]=N498 B[2]=N497 B[1]=FE_DBTN22_n5504
+ B[0]=N495 SUM[35]=N566 SUM[34]=N565 SUM[33]=N564 SUM[32]=N563 SUM[31]=N562
+ SUM[30]=N561 SUM[29]=N560 SUM[28]=N559 SUM[27]=N558 SUM[26]=N557 SUM[25]=N556
+ SUM[24]=N555 SUM[23]=N554 SUM[22]=N553 SUM[21]=N552 SUM[20]=N551 SUM[19]=N550
+ SUM[18]=N549 SUM[17]=N548 SUM[16]=N547 SUM[15]=N546 SUM[14]=N545 SUM[13]=N544
+ SUM[12]=N543 SUM[11]=N542 SUM[10]=N541 SUM[9]=N540 SUM[8]=N539 SUM[7]=N538
+ SUM[6]=N537 SUM[5]=N536 SUM[4]=N535 SUM[3]=N534 SUM[2]=N533 SUM[1]=N532
+ SUM[0]=N531
Xr2246 CONV_DW_mult_uns_31_0 $PINS a[19]=FE_OFN5519_register_1__19 a[18]=n5105
+ a[17]=FE_OFN6029_register_1__17 a[16]=FE_OFN5520_register_1__16
+ a[15]=FE_OFN5521_register_1__15 a[14]=FE_OFN5522_register_1__14
+ a[13]=register[1][13] a[12]=FE_OFN5997_register_1__12 a[11]=FE_UNCONNECTEDZ_120
+ a[10]=FE_OFN6003_register_1__10 a[9]=FE_OFN5524_register_1__9
+ a[8]=FE_OFN5525_register_1__8 a[7]=FE_OFN5526_register_1__7
+ a[6]=FE_OFN6021_register_1__6 a[5]=FE_OFN6015_register_1__5
+ a[4]=FE_OFN5527_register_1__4 a[3]=FE_OFN5528_register_1__3 a[2]=N1145
+ a[1]=register[1][1] a[0]=FE_OFN5998_register_1__0 product[33]=N1175
+ product[32]=N1174 product[31]=N1173 product[30]=N1172 product[29]=N1171
+ product[28]=N1170 product[27]=N1169 product[26]=N1168 product[25]=N1167
+ product[24]=N1166 product[23]=N1165 product[22]=N1164 product[21]=N1163
+ product[20]=N1162 product[19]=N1161 product[18]=N1160 product[17]=N1159
+ product[16]=N1158 product[15]=N1157 product[14]=N1156 product[13]=N1155
+ product[12]=N1154 product[11]=N1153 product[10]=N1152 product[9]=N1151
+ product[8]=N1150 product[7]=N1149 product[6]=N1148 product[5]=N1147
+ product[4]=N1146 product[3]=FE_UNCONNECTEDZ_121 product[2]=N1144
+ product[1]=N1143 product[0]=SYNOPSYS_UNCONNECTED__27
+ _register_1_11=FE_OFN6002_register_1__11 n4988=n4988
+ FE_OFN55_register_1__6=register[1][6]
+ FE_OFN57_register_1__13=FE_OFN5523_register_1__13
Xr2242 CONV_DW_mult_uns_49_0 $PINS a[19]=FE_OFN5582_register_8__19
+ a[18]=FE_OFN5583_register_8__18 a[17]=FE_DBTN49_register_8_17
+ a[16]=FE_OFN5713_register_8__16 a[15]=FE_OFN5993_register_8__15
+ a[14]=FE_OFN5584_register_8__14 a[13]=FE_OFN5717_register_8__13
+ a[12]=FE_OFN5585_register_8__12 a[11]=FE_DBTN43_register_8_11
+ a[10]=FE_DBTN1172_register_8_10 a[9]=FE_OFN5586_register_8__9
+ a[8]=FE_OFN5731_register_8__8 a[7]=FE_DBTN39_register_8_7
+ a[6]=FE_UNCONNECTEDZ_122 a[5]=FE_OFN5719_register_8__5
+ a[4]=FE_OFN6018_register_8__4 a[3]=FE_DBTN1169_register_8_3 a[2]=register[8][2]
+ a[1]=FE_OFN5953_n5323 a[0]=FE_DBTN8_N1034 product[34]=N1033 product[33]=N1032
+ product[32]=N1031 product[31]=N1030 product[30]=N1029 product[29]=N1028
+ product[28]=N1027 product[27]=N1026 product[26]=N1025 product[25]=N1024
+ product[24]=N1023 product[23]=N1022 product[22]=N1021 product[21]=N1020
+ product[20]=N1019 product[19]=N1018 product[18]=N1017 product[17]=N1016
+ product[16]=N1015 product[15]=N1014 product[14]=N1013 product[13]=N1012
+ product[12]=N1011 product[11]=N1010 product[10]=N1009 product[9]=N1008
+ product[8]=N1007 product[7]=N1006 product[6]=N1005 product[5]=N1004
+ product[4]=N1003 product[3]=N1002 product[2]=N1001 product[1]=N1000
+ product[0]=FE_UNCONNECTEDZ_123 p1=FE_DBTN8_N1034 p2=N1424
+ p3=FE_DBTN34_register_8_2 p4=FE_OFN6011_register_8__3
+ p5=FE_DBTN1164_register_8_4 p6=FE_DBTN1163_register_8_5
+ p7=FE_DBTN38_register_8_6 p8=FE_OFN5771_register_8__7
+ p9=FE_DBTN1165_register_8_8 p10=register[8][9] p11=FE_OFN5666_register_8__10
+ p12=FE_OFN6036_register_8__11 p13=register[8][12] p14=FE_DBTN45_register_8_13
+ p15=FE_OFN304_register_8__14 p16=FE_OFN5709_register_8__15
+ p17=FE_OFN306_register_8__16 p18=FE_OFN5691_register_8__17
+ p19=FE_DBTN1161_register_8_18 p20=FE_DBTN1176_register_8_19
+ FE_OFN6_register_8__12=FE_OFN5819_register_8__12
+ FE_OFN10_register_8__3=FE_DBTN1169_register_8_3 FE_OFN11_N1424=FE_OFN5648_n5323
+ FE_OFN16_register_8__9=FE_OFN5793_register_8__9 FE_OFN20_N1034=FE_OFN5730_N999
+ FE_OFN18_N1034=FE_OFN6005_N999 FE_OFN22_register_8__14=register[8][14]
+ FE_OFN24_register_8__16=FE_OFN5979_register_8__16
+ FE_OFN40_register_8__19=FE_DBTN1176_register_8_19
+ FE_OFN46_register_8__18=register[8][18]
+ FE_OFN53_register_8__12=FE_OFN605_register_8__12
+ _register_8_6=FE_OFN5587_register_8__6 p21=FE_DBTN1161_register_8_18
+ p22=FE_DBTN1166_register_8_15 FE_OFN64_register_8__8=FE_OFN5732_register_8__8
+ FE_OFN65_register_8__11=FE_OFN5742_register_8__11
+ FE_OFN70_register_8__2=FE_OFN5777_register_8__2
+ FE_OFN75_register_8__18=FE_OFN5822_register_8__18
+ FE_OFN82_register_8__19=FE_DBTN1176_register_8_19
+ FE_OFN87_register_8__16=FE_OFN5980_register_8__16
+ FE_OFN88_register_8__15=FE_OFN5993_register_8__15
+ FE_OFN96_n=FE_OFN5587_register_8__6 FE_OFN102_n=FE_OFN5586_register_8__9
Xr2258 CONV_DW_mult_uns_36_0_0 $PINS a[35]=n5142 a[34]=n5142 a[33]=n5142
+ a[32]=n5142 a[31]=n5142 a[30]=n5142 a[29]=n5142 a[28]=n5142 a[27]=n5142
+ a[26]=n5142 a[25]=n5142 a[24]=n5142 a[23]=n5142 a[22]=n5142 a[21]=n5142
+ a[20]=n5142 a[19]=r2257/DIFF[19] a[18]=r2257/DIFF[18] a[17]=r2257/DIFF[17]
+ a[16]=r2257/DIFF[16] a[15]=r2257/DIFF[15] a[14]=r2257/DIFF[14] a[13]=n6745
+ a[12]=n5250 a[11]=n5251 a[10]=r2257/DIFF[10] a[9]=r2257/DIFF[9] a[8]=n4885
+ a[7]=r2257/DIFF[7] a[6]=r2257/DIFF[6] a[5]=r2257/DIFF[5] a[4]=r2257/DIFF[4]
+ a[3]=r2257/DIFF[3] a[2]=r2257/DIFF[2] a[1]=r2257/DIFF[1]
+ a[0]=FE_UNCONNECTEDZ_124 product[49]=SYNOPSYS_UNCONNECTED__28
+ product[48]=SYNOPSYS_UNCONNECTED__29 product[47]=SYNOPSYS_UNCONNECTED__30
+ product[46]=SYNOPSYS_UNCONNECTED__31 product[45]=SYNOPSYS_UNCONNECTED__32
+ product[44]=SYNOPSYS_UNCONNECTED__33 product[43]=SYNOPSYS_UNCONNECTED__34
+ product[42]=SYNOPSYS_UNCONNECTED__35 product[41]=SYNOPSYS_UNCONNECTED__36
+ product[40]=SYNOPSYS_UNCONNECTED__37 product[39]=SYNOPSYS_UNCONNECTED__38
+ product[38]=SYNOPSYS_UNCONNECTED__39 product[37]=SYNOPSYS_UNCONNECTED__40
+ product[36]=SYNOPSYS_UNCONNECTED__41 product[35]=N1583 product[34]=N1582
+ product[33]=N1581 product[32]=N1580 product[31]=N1579 product[30]=N1578
+ product[29]=N1577 product[28]=N1576 product[27]=N1575 product[26]=N1574
+ product[25]=N1573 product[24]=N1572 product[23]=N1571 product[22]=N1570
+ product[21]=N1569 product[20]=N1568 product[19]=N1567 product[18]=N1566
+ product[17]=N1565 product[16]=N1564 product[15]=N1563 product[14]=N1562
+ product[13]=N1561 product[12]=N1560 product[11]=N1559 product[10]=N1558
+ product[9]=N1557 product[8]=N1556 product[7]=N1555 product[6]=N1554
+ product[5]=N1553 product[4]=N1552 product[3]=N1551 product[2]=N1550
+ product[1]=N1549 product[0]=FE_UNCONNECTEDZ_125 FE_OFN45_N1548=N1618
+ FE_DBTN1180_N1618=FE_DBTN1180_N1618
Xr2256 CONV_DW01_add_16 $PINS A[35]=N1490 A[34]=N1489 A[33]=N1488 A[32]=N1487
+ A[31]=N1486 A[30]=N1485 A[29]=N1484 A[28]=N1483 A[27]=N1482 A[26]=N1481
+ A[25]=N1480 A[24]=N1479 A[23]=N1478 A[22]=N1477 A[21]=N1476 A[20]=N1475
+ A[19]=N1474 A[18]=N1473 A[17]=N1472 A[16]=N1471 A[15]=N1470 A[14]=N1469
+ A[13]=N1468 A[12]=N1467 A[11]=N1466 A[10]=N1465 A[9]=N1464 A[8]=N1463
+ A[7]=N1462 A[6]=N1461 A[5]=N1460 A[4]=N1459 A[3]=N1458 A[2]=N1457 A[1]=N1456
+ A[0]=N1455 B[35]=N1385 B[34]=N1384 B[33]=N1383 B[32]=N1382 B[31]=N1381
+ B[30]=N1380 B[29]=N1379 B[28]=N1378 B[27]=N1377 B[26]=N1376 B[25]=N1375
+ B[24]=N1374 B[23]=N1373 B[22]=N1372 B[21]=N1371 B[20]=N1370 B[19]=N1369
+ B[18]=N1368 B[17]=N1367 B[16]=N1366 B[15]=N1365 B[14]=N1364 B[13]=N1363
+ B[12]=N1362 B[11]=N1361 B[10]=N1360 B[9]=N1359 B[8]=N1358 B[7]=N1357 B[6]=N1356
+ B[5]=N1355 B[4]=N1354 B[3]=N1353 B[2]=N1352 B[1]=N1351 B[0]=N1350 SUM[35]=N1526
+ SUM[34]=N1525 SUM[33]=N1524 SUM[32]=N1523 SUM[31]=N1522 SUM[30]=N1521
+ SUM[29]=N1520 SUM[28]=N1519 SUM[27]=N1518 SUM[26]=N1517 SUM[25]=N1516
+ SUM[24]=N1515 SUM[23]=N1514 SUM[22]=N1513 SUM[21]=N1512 SUM[20]=N1511
+ SUM[19]=N1510 SUM[18]=N1509 SUM[17]=N1508 SUM[16]=N1507 SUM[15]=N1506
+ SUM[14]=N1505 SUM[13]=N1504 SUM[12]=N1503 SUM[11]=N1502 SUM[10]=N1501
+ SUM[9]=N1500 SUM[8]=N1499 SUM[7]=N1498 SUM[6]=N1497 SUM[5]=N1496 SUM[4]=N1495
+ SUM[3]=N1494 SUM[2]=N1493 SUM[1]=N1492 SUM[0]=N1491
Xr2252 CONV_DW01_add_15 $PINS A[35]=N1246 A[34]=N1245 A[33]=N1244 A[32]=N1243
+ A[31]=N1242 A[30]=N1241 A[29]=N1240 A[28]=N1239 A[27]=N1238 A[26]=N1237
+ A[25]=N1236 A[24]=N1235 A[23]=N1234 A[22]=N1233 A[21]=N1232 A[20]=N1231
+ A[19]=N1230 A[18]=N1229 A[17]=N1228 A[16]=N1227 A[15]=N1226 A[14]=N1225
+ A[13]=N1224 A[12]=N1223 A[11]=N1222 A[10]=N1221 A[9]=N1220 A[8]=N1219
+ A[7]=N1218 A[6]=N1217 A[5]=N1216 A[4]=N1215 A[3]=N1214 A[2]=N1213 A[1]=N1212
+ A[0]=FE_OFN5775_n5319 B[35]=FE_UNCONNECTEDZ_126 B[34]=N1349 B[33]=N1348
+ B[32]=N1347 B[31]=N1346 B[30]=N1345 B[29]=N1344 B[28]=N1343 B[27]=N1342
+ B[26]=N1341 B[25]=N1340 B[24]=N1339 B[23]=N1338 B[22]=N1337 B[21]=N1336
+ B[20]=N1335 B[19]=N1334 B[18]=N1333 B[17]=N1332 B[16]=N1331 B[15]=N1330
+ B[14]=N1329 B[13]=N1328 B[12]=N1327 B[11]=N1326 B[10]=N1325 B[9]=N1324
+ B[8]=N1323 B[7]=N1322 B[6]=N1321 B[5]=N1320 B[4]=N1319 B[3]=N1318 B[2]=N1317
+ B[1]=FE_OCPN6208_N1316 B[0]=N1315 SUM[35]=N1385 SUM[34]=N1384 SUM[33]=N1383
+ SUM[32]=N1382 SUM[31]=N1381 SUM[30]=N1380 SUM[29]=N1379 SUM[28]=N1378
+ SUM[27]=N1377 SUM[26]=N1376 SUM[25]=N1375 SUM[24]=N1374 SUM[23]=N1373
+ SUM[22]=N1372 SUM[21]=N1371 SUM[20]=N1370 SUM[19]=N1369 SUM[18]=N1368
+ SUM[17]=N1367 SUM[16]=N1366 SUM[15]=N1365 SUM[14]=N1364 SUM[13]=N1363
+ SUM[12]=N1362 SUM[11]=N1361 SUM[10]=N1360 SUM[9]=N1359 SUM[8]=N1358
+ SUM[7]=N1357 SUM[6]=N1356 SUM[5]=N1355 SUM[4]=N1354 SUM[3]=N1353 SUM[2]=N1352
+ SUM[1]=N1351 SUM[0]=N1350
Xr2232 CONV_DW01_add_9 $PINS A[35]=N566 A[34]=N565 A[33]=N564 A[32]=N563
+ A[31]=N562 A[30]=N561 A[29]=N560 A[28]=N559 A[27]=N558 A[26]=N557 A[25]=N556
+ A[24]=N555 A[23]=N554 A[22]=N553 A[21]=N552 A[20]=N551 A[19]=N550 A[18]=N549
+ A[17]=N548 A[16]=N547 A[15]=N546 A[14]=N545 A[13]=N544 A[12]=N543 A[11]=N542
+ A[10]=N541 A[9]=N540 A[8]=N539 A[7]=N538 A[6]=N537 A[5]=N536 A[4]=N535
+ A[3]=N534 A[2]=N533 A[1]=N532 A[0]=FE_OFN5998_register_1__0 B[35]=N670
+ B[34]=N669 B[33]=N668 B[32]=N667 B[31]=N666 B[30]=N665 B[29]=N664 B[28]=N663
+ B[27]=N662 B[26]=N661 B[25]=N660 B[24]=N659 B[23]=N658 B[22]=N657 B[21]=N656
+ B[20]=N655 B[19]=N654 B[18]=N653 B[17]=N652 B[16]=N651 B[15]=N650 B[14]=N649
+ B[13]=N648 B[12]=N647 B[11]=N646 B[10]=N645 B[9]=N644 B[8]=N643 B[7]=N642
+ B[6]=N641 B[5]=N640 B[4]=N639 B[3]=N638 B[2]=N637 B[1]=N636 B[0]=N15861
+ SUM[35]=N706 SUM[34]=N705 SUM[33]=N704 SUM[32]=N703 SUM[31]=N702 SUM[30]=N701
+ SUM[29]=N700 SUM[28]=N699 SUM[27]=N698 SUM[26]=N697 SUM[25]=N696 SUM[24]=N695
+ SUM[23]=N694 SUM[22]=N693 SUM[21]=N692 SUM[20]=N691 SUM[19]=N690 SUM[18]=N689
+ SUM[17]=N688 SUM[16]=N687 SUM[15]=N686 SUM[14]=N685 SUM[13]=N684 SUM[12]=N683
+ SUM[11]=N682 SUM[10]=N681 SUM[9]=N680 SUM[8]=N679 SUM[7]=N678 SUM[6]=N677
+ SUM[5]=N676 SUM[4]=N675 SUM[3]=N674 SUM[2]=N673 SUM[1]=N672 SUM[0]=N671
Xr2243 CONV_DW01_sub_4 $PINS A[35]=N998 A[34]=N997 A[33]=N996 A[32]=N995
+ A[31]=N994 A[30]=N993 A[29]=N992 A[28]=N991 A[27]=N990 A[26]=N989 A[25]=N988
+ A[24]=N987 A[23]=N986 A[22]=N985 A[21]=N984 A[20]=N983 A[19]=N982 A[18]=N981
+ A[17]=N980 A[16]=N979 A[15]=N978 A[14]=N977 A[13]=N976 A[12]=N975 A[11]=N974
+ A[10]=N973 A[9]=N972 A[8]=N971 A[7]=N970 A[6]=N969 A[5]=N968 A[4]=N967
+ A[3]=N966 A[2]=FE_OFN5848_FE_DBTN21_N1711 A[1]=FE_UNCONNECTEDZ_127
+ A[0]=FE_UNCONNECTEDZ_128 B[35]=FE_UNCONNECTEDZ_129 B[34]=N1033 B[33]=N1032
+ B[32]=N1031 B[31]=N1030 B[30]=N1029 B[29]=N1028 B[28]=N1027 B[27]=N1026
+ B[26]=N1025 B[25]=N1024 B[24]=N1023 B[23]=N1022 B[22]=N1021 B[21]=N1020
+ B[20]=N1019 B[19]=N1018 B[18]=N1017 B[17]=N1016 B[16]=N1015 B[15]=N1014
+ B[14]=N1013 B[13]=N1012 B[12]=N1011 B[11]=N1010 B[10]=N1009 B[9]=N1008
+ B[8]=N1007 B[7]=N1006 B[6]=N1005 B[5]=N1004 B[4]=N1003 B[3]=N1002 B[2]=N1001
+ B[1]=N1000 B[0]=FE_OFN5728_N999 DIFF[35]=N1069 DIFF[34]=N1068 DIFF[33]=N1067
+ DIFF[32]=N1066 DIFF[31]=N1065 DIFF[30]=N1064 DIFF[29]=N1063 DIFF[28]=N1062
+ DIFF[27]=N1061 DIFF[26]=N1060 DIFF[25]=N1059 DIFF[24]=N1058 DIFF[23]=N1057
+ DIFF[22]=N1056 DIFF[21]=N1055 DIFF[20]=N1054 DIFF[19]=N1053 DIFF[18]=N1052
+ DIFF[17]=N1051 DIFF[16]=N1050 DIFF[15]=N1049 DIFF[14]=N1048 DIFF[13]=N1047
+ DIFF[12]=N1046 DIFF[11]=N1045 DIFF[10]=N1044 DIFF[9]=N1043 DIFF[8]=N1042
+ DIFF[7]=N1041 DIFF[6]=N1040 DIFF[5]=N1039 DIFF[4]=N1038 DIFF[3]=N1037
+ DIFF[2]=N1036 DIFF[1]=N1035 DIFF[0]=N1034
Xr2260 CONV_DW01_sub_5 $PINS A[35]=N1583 A[34]=N1582 A[33]=N1581 A[32]=N1580
+ A[31]=N1579 A[30]=N1578 A[29]=N1577 A[28]=N1576 A[27]=N1575 A[26]=N1574
+ A[25]=N1573 A[24]=N1572 A[23]=N1571 A[22]=N1570 A[21]=N1569 A[20]=N1568
+ A[19]=N1567 A[18]=N1566 A[17]=N1565 A[16]=N1564 A[15]=N1563 A[14]=N1562
+ A[13]=N1561 A[12]=N1560 A[11]=N1559 A[10]=N1558 A[9]=N1557 A[8]=N1556
+ A[7]=N1555 A[6]=N1554 A[5]=N1553 A[4]=N1552 A[3]=N1551 A[2]=N1550 A[1]=N1549
+ A[0]=FE_DBTN1180_N1618 B[35]=FE_UNCONNECTEDZ_130 B[34]=FE_UNCONNECTEDZ_131
+ B[33]=N1617 B[32]=N1616 B[31]=N1615 B[30]=N1614 B[29]=N1613 B[28]=N1612
+ B[27]=N1611 B[26]=N1610 B[25]=N1609 B[24]=N1608 B[23]=N1607 B[22]=N1606
+ B[21]=N1605 B[20]=N1604 B[19]=N1603 B[18]=N1602 B[17]=N1601 B[16]=N1600
+ B[15]=N1599 B[14]=N1598 B[13]=N1597 B[12]=N1596 B[11]=N1595 B[10]=N1594
+ B[9]=N1593 B[8]=N1592 B[7]=N1591 B[6]=N1590 B[5]=N1589 B[4]=N1588 B[3]=N1587
+ B[2]=FE_OFN5883_N567 B[1]=FE_UNCONNECTEDZ_132 B[0]=FE_UNCONNECTEDZ_133
+ DIFF[35]=N1653 DIFF[34]=N1652 DIFF[33]=N1651 DIFF[32]=N1650 DIFF[31]=N1649
+ DIFF[30]=N1648 DIFF[29]=N1647 DIFF[28]=N1646 DIFF[27]=N1645 DIFF[26]=N1644
+ DIFF[25]=N1643 DIFF[24]=N1642 DIFF[23]=N1641 DIFF[22]=N1640 DIFF[21]=N1639
+ DIFF[20]=N1638 DIFF[19]=N1637 DIFF[18]=N1636 DIFF[17]=N1635 DIFF[16]=N1634
+ DIFF[15]=N1633 DIFF[14]=N1632 DIFF[13]=N1631 DIFF[12]=N1630 DIFF[11]=N1629
+ DIFF[10]=N1628 DIFF[9]=N1627 DIFF[8]=N1626 DIFF[7]=N1625 DIFF[6]=N1624
+ DIFF[5]=N1623 DIFF[4]=N1622 DIFF[3]=N1621 DIFF[2]=N1620 DIFF[1]=N1619
+ DIFF[0]=FE_UNCONNECTEDZ_134
Xr2248 CONV_DW01_add_13 $PINS A[35]=FE_UNCONNECTEDZ_135
+ A[34]=FE_UNCONNECTEDZ_136 A[33]=N1175 A[32]=N1174 A[31]=N1173 A[30]=N1172
+ A[29]=N1171 A[28]=N1170 A[27]=N1169 A[26]=N1168 A[25]=N1167 A[24]=N1166
+ A[23]=N1165 A[22]=N1164 A[21]=N1163 A[20]=N1162 A[19]=N1161 A[18]=N1160
+ A[17]=N1159 A[16]=N1158 A[15]=N1157 A[14]=N1156 A[13]=N1155 A[12]=N1154
+ A[11]=N1153 A[10]=N1152 A[9]=N1151 A[8]=N1150 A[7]=N1149 A[6]=N1148 A[5]=N1147
+ A[4]=N1146 A[3]=N1145 A[2]=register[1][1] A[1]=FE_OFN5998_register_1__0
+ A[0]=FE_UNCONNECTEDZ_137 B[35]=FE_UNCONNECTEDZ_138 B[34]=N1210 B[33]=N1209
+ B[32]=N1208 B[31]=N1207 B[30]=N1206 B[29]=N1205 B[28]=N1204 B[27]=N1203
+ B[26]=N1202 B[25]=N1201 B[24]=N1200 B[23]=N1199 B[22]=N1198 B[21]=N1197
+ B[20]=N1196 B[19]=N1195 B[18]=N1194 B[17]=N1193 B[16]=N1192 B[15]=N1191
+ B[14]=N1190 B[13]=N1189 B[12]=N1188 B[11]=N1187 B[10]=N1186 B[9]=N1185
+ B[8]=N1184 B[7]=N1183 B[6]=N1182 B[5]=N1181 B[4]=N1180 B[3]=N1179 B[2]=N1178
+ B[1]=FE_OFN6039_N1177 B[0]=N1176 SUM[35]=N1246 SUM[34]=N1245 SUM[33]=N1244
+ SUM[32]=N1243 SUM[31]=N1242 SUM[30]=N1241 SUM[29]=N1240 SUM[28]=N1239
+ SUM[27]=N1238 SUM[26]=N1237 SUM[25]=N1236 SUM[24]=N1235 SUM[23]=N1234
+ SUM[22]=N1233 SUM[21]=N1232 SUM[20]=N1231 SUM[19]=N1230 SUM[18]=N1229
+ SUM[17]=N1228 SUM[16]=N1227 SUM[15]=N1226 SUM[14]=N1225 SUM[13]=N1224
+ SUM[12]=N1223 SUM[11]=N1222 SUM[10]=N1221 SUM[9]=N1220 SUM[8]=N1219
+ SUM[7]=N1218 SUM[6]=N1217 SUM[5]=N1216 SUM[4]=N1215 SUM[3]=N1214 SUM[2]=N1213
+ SUM[1]=N1212 SUM[0]=N1211
Xr2235 CONV_DW01_add_29 $PINS A[35]=N777 A[34]=N776 A[33]=N775 A[32]=N774
+ A[31]=N773 A[30]=N772 A[29]=N771 A[28]=N770 A[27]=N769 A[26]=N768 A[25]=N767
+ A[24]=N766 A[23]=N765 A[22]=N764 A[21]=N763 A[20]=N762 A[19]=N761 A[18]=N760
+ A[17]=N759 A[16]=N758 A[15]=N757 A[14]=N756 A[13]=N755 A[12]=N754 A[11]=N753
+ A[10]=N752 A[9]=N751 A[8]=N750 A[7]=N749 A[6]=N748 A[5]=N747 A[4]=N746
+ A[3]=N745 A[2]=N744 A[1]=N743 A[0]=N707 B[35]=N706 B[34]=N705 B[33]=N704
+ B[32]=N703 B[31]=N702 B[30]=N701 B[29]=N700 B[28]=N699 B[27]=N698 B[26]=N697
+ B[25]=N696 B[24]=N695 B[23]=N694 B[22]=N693 B[21]=N692 B[20]=N691 B[19]=N690
+ B[18]=N689 B[17]=N688 B[16]=N687 B[15]=N686 B[14]=N685 B[13]=N684 B[12]=N683
+ B[11]=N682 B[10]=N681 B[9]=N680 B[8]=N679 B[7]=N678 B[6]=N677 B[5]=N676
+ B[4]=N675 B[3]=N674 B[2]=N673 B[1]=N672 B[0]=N671 SUM[35]=N813 SUM[34]=N812
+ SUM[33]=N811 SUM[32]=N810 SUM[31]=N809 SUM[30]=N808 SUM[29]=N807 SUM[28]=N806
+ SUM[27]=N805 SUM[26]=N804 SUM[25]=N803 SUM[24]=N802 SUM[23]=N801 SUM[22]=N800
+ SUM[21]=N799 SUM[20]=N798 SUM[19]=N797 SUM[18]=N796 SUM[17]=N795 SUM[16]=N794
+ SUM[15]=N793 SUM[14]=N792 SUM[13]=N791 SUM[12]=N790 SUM[11]=N789 SUM[10]=N788
+ SUM[9]=N787 SUM[8]=N786 SUM[7]=N785 SUM[6]=N784 SUM[5]=N783 SUM[4]=N782
+ SUM[3]=N781 SUM[2]=N780 SUM[1]=N779 SUM[0]=N778
Xr2231 CONV_DW01_add_30 $PINS A[35]=FE_UNCONNECTEDZ_139 A[34]=N601 A[33]=N600
+ A[32]=N599 A[31]=N598 A[30]=N597 A[29]=N596 A[28]=N595 A[27]=N594 A[26]=N593
+ A[25]=N592 A[24]=N591 A[23]=N590 A[22]=N589 A[21]=N588 A[20]=N587 A[19]=N586
+ A[18]=N585 A[17]=N584 A[16]=N583 A[15]=N582 A[14]=N581 A[13]=N580 A[12]=N579
+ A[11]=N578 A[10]=N577 A[9]=N576 A[8]=N575 A[7]=N574 A[6]=N573 A[5]=N572
+ A[4]=N571 A[3]=N570 A[2]=N569 A[1]=N568 A[0]=N567 B[35]=FE_UNCONNECTEDZ_140
+ B[34]=FE_UNCONNECTEDZ_141 B[33]=FE_UNCONNECTEDZ_142 B[32]=N634 B[31]=N633
+ B[30]=N632 B[29]=N631 B[28]=N630 B[27]=N629 B[26]=N628 B[25]=N627 B[24]=N626
+ B[23]=N625 B[22]=N624 B[21]=N623 B[20]=N622 B[19]=N621 B[18]=N620 B[17]=N619
+ B[16]=N618 B[15]=N617 B[14]=N616 B[13]=N615 B[12]=N614 B[11]=n5103
+ B[10]=FE_OFN5936_N612 B[9]=FE_OFN89_N611 B[8]=FE_OFN5591_N610
+ B[7]=FE_OFN5747_N609 B[6]=FE_OFN5590_N608 B[5]=FE_UNCONNECTEDZ_143
+ B[4]=FE_OFN5588_N606 B[3]=FE_OFN6039_N1177 B[2]=FE_OFN5775_n5319
+ B[1]=FE_UNCONNECTEDZ_144 B[0]=FE_UNCONNECTEDZ_145 SUM[35]=N670 SUM[34]=N669
+ SUM[33]=N668 SUM[32]=N667 SUM[31]=N666 SUM[30]=N665 SUM[29]=N664 SUM[28]=N663
+ SUM[27]=N662 SUM[26]=N661 SUM[25]=N660 SUM[24]=N659 SUM[23]=N658 SUM[22]=N657
+ SUM[21]=N656 SUM[20]=N655 SUM[19]=N654 SUM[18]=N653 SUM[17]=N652 SUM[16]=N651
+ SUM[15]=N650 SUM[14]=N649 SUM[13]=N648 SUM[12]=N647 SUM[11]=N646 SUM[10]=N645
+ SUM[9]=N644 SUM[8]=N643 SUM[7]=N642 SUM[6]=N641 SUM[5]=N640 SUM[4]=N639
+ SUM[3]=N638 SUM[2]=N637 SUM[1]=N636 SUM[0]=FE_UNCONNECTEDZ_146
+ N607=FE_OFN6168_N607 N611=FE_OFN5592_N611
Xr2245 CONV_DW01_add_28 $PINS A[35]=N813 A[34]=N812 A[33]=N811 A[32]=N810
+ A[31]=N809 A[30]=N808 A[29]=N807 A[28]=N806 A[27]=N805 A[26]=N804 A[25]=N803
+ A[24]=N802 A[23]=N801 A[22]=N800 A[21]=N799 A[20]=N798 A[19]=N797 A[18]=N796
+ A[17]=N795 A[16]=N794 A[15]=N793 A[14]=N792 A[13]=N791 A[12]=N790 A[11]=N789
+ A[10]=N788 A[9]=N787 A[8]=N786 A[7]=N785 A[6]=N784 A[5]=N783 A[4]=N782
+ A[3]=N781 A[2]=N780 A[1]=N779 A[0]=N778 B[35]=N1105 B[34]=N1104 B[33]=N1103
+ B[32]=N1102 B[31]=N1101 B[30]=N1100 B[29]=N1099 B[28]=N1098 B[27]=N1097
+ B[26]=N1096 B[25]=N1095 B[24]=N1094 B[23]=N1093 B[22]=N1092 B[21]=N1091
+ B[20]=N1090 B[19]=N1089 B[18]=N1088 B[17]=N1087 B[16]=N1086 B[15]=N1085
+ B[14]=N1084 B[13]=N1083 B[12]=N1082 B[11]=N1081 B[10]=N1080 B[9]=N1079
+ B[8]=N1078 B[7]=N1077 B[6]=N1076 B[5]=N1075 B[4]=N1074 B[3]=N1073 B[2]=N1072
+ B[1]=N1071 B[0]=N1070 SUM[35]=n192 SUM[34]=n193 SUM[33]=n194 SUM[32]=n195
+ SUM[31]=n196 SUM[30]=n197 SUM[29]=n198 SUM[28]=n199 SUM[27]=n200 SUM[26]=n201
+ SUM[25]=n202 SUM[24]=n203 SUM[23]=n204 SUM[22]=n205 SUM[21]=n206 SUM[20]=n207
+ SUM[19]=n208 SUM[18]=n209 SUM[17]=n210 SUM[16]=n211 SUM[15]=n212 SUM[14]=n213
+ SUM[13]=n214 SUM[12]=n215 SUM[11]=n216 SUM[10]=n217 SUM[9]=n218 SUM[8]=n219
+ SUM[7]=n220 SUM[6]=n221 SUM[5]=n222 SUM[4]=n223 SUM[3]=n224 SUM[2]=n225
+ SUM[1]=n226 SUM[0]=n227
Xr2261 CONV_DW_mult_uns_37_0_0_0 $PINS a[35]=n5256 a[34]=n5256 a[33]=n5256
+ a[32]=n5256 a[31]=n5256 a[30]=n5256 a[29]=n5256 a[28]=n5256 a[27]=n5256
+ a[26]=n5256 a[25]=n5256 a[24]=n5256 a[23]=n5256 a[22]=n5256 a[21]=n5256
+ a[20]=n5256 a[19]=n5318 a[18]=r2240/DIFF[18] a[17]=r2240/DIFF[17] a[16]=n4982
+ a[15]=FE_OFN549_n4975 a[14]=n4931 a[13]=r2240/DIFF[13] a[12]=FE_OFN5405_n4983
+ a[11]=r2240/DIFF[11] a[10]=n4887 a[9]=FE_OFN5416_r2240_DIFF_9 a[8]=n5314
+ a[7]=FE_OFN6141_n a[6]=n4889 a[5]=r2240/DIFF[5] a[4]=r2240/DIFF[4] a[3]=n5244
+ a[2]=n5243 a[1]=n5269 a[0]=FE_OFN5853_FE_DBTN21_N1711
+ product[49]=SYNOPSYS_UNCONNECTED__42 product[48]=SYNOPSYS_UNCONNECTED__43
+ product[47]=SYNOPSYS_UNCONNECTED__44 product[46]=SYNOPSYS_UNCONNECTED__45
+ product[45]=SYNOPSYS_UNCONNECTED__46 product[44]=SYNOPSYS_UNCONNECTED__47
+ product[43]=SYNOPSYS_UNCONNECTED__48 product[42]=SYNOPSYS_UNCONNECTED__49
+ product[41]=SYNOPSYS_UNCONNECTED__50 product[40]=SYNOPSYS_UNCONNECTED__51
+ product[39]=SYNOPSYS_UNCONNECTED__52 product[38]=SYNOPSYS_UNCONNECTED__53
+ product[37]=SYNOPSYS_UNCONNECTED__54 product[36]=SYNOPSYS_UNCONNECTED__55
+ product[35]=SYNOPSYS_UNCONNECTED__56 product[34]=N1709 product[33]=N1708
+ product[32]=N1707 product[31]=N1706 product[30]=N1705 product[29]=N1704
+ product[28]=N1703 product[27]=N1702 product[26]=N1701 product[25]=N1700
+ product[24]=N1699 product[23]=N1698 product[22]=N1697 product[21]=N1696
+ product[20]=N1695 product[19]=N1694 product[18]=N1693 product[17]=N1692
+ product[16]=N1691 product[15]=N1726 product[14]=N1725 product[13]=N1724
+ product[12]=N1723 product[11]=N1722 product[10]=N1721 product[9]=N1720
+ product[8]=N1719 product[7]=N1718 product[6]=N1717 product[5]=N1716
+ product[4]=N1715 product[3]=N1714 product[2]=N1713 product[1]=N1712
+ product[0]=FE_UNCONNECTEDZ_147 n4908=n5318 n4907=FE_OFN6060_n4907
+ n4906=FE_OFN6157_n4906 n4905=FE_OFN6150_n4905 n6739=n6739 n5280=n4887
+ n5286=n5286 p1=FE_DBTN21_N1711 FE_OFN38_N1711=FE_OFN5855_FE_DBTN21_N1711
+ p_2=n4887 p_3=n5318 p_4=n5314 p_5=n4905 p_6=n4931 FE_OFN83_n=FE_OFN5966_n
+ FE_OFN99_FE_DBTN21_N1711=FE_OFN5855_FE_DBTN21_N1711
Xr2237 CONV_DW_mult_uns_35_0_0_0 $PINS a[35]=n284 a[34]=n284 a[33]=n284
+ a[32]=n284 a[31]=n284 a[30]=n284 a[29]=n284 a[28]=n284 a[27]=n284 a[26]=n284
+ a[25]=n284 a[24]=n284 a[23]=n284 a[22]=n284 a[21]=n284 a[20]=n284
+ a[19]=r2236/DIFF[19] a[18]=r2236/DIFF[18] a[17]=r2236/DIFF[17]
+ a[16]=r2236/DIFF[16] a[15]=n5254 a[14]=r2236/DIFF[14] a[13]=r2236/DIFF[13]
+ a[12]=r2236/DIFF[12] a[11]=r2236/DIFF[11] a[10]=n2468 a[9]=r2236/DIFF[9]
+ a[8]=r2236/DIFF[8] a[7]=r2236/DIFF[7] a[6]=r2236/DIFF[6] a[5]=r2236/DIFF[5]
+ a[4]=r2236/DIFF[4] a[3]=r2236/DIFF[3] a[2]=r2236/DIFF[2] a[1]=r2236/DIFF[1]
+ a[0]=N1315 product[51]=SYNOPSYS_UNCONNECTED__57
+ product[50]=SYNOPSYS_UNCONNECTED__58 product[49]=SYNOPSYS_UNCONNECTED__59
+ product[48]=SYNOPSYS_UNCONNECTED__60 product[47]=SYNOPSYS_UNCONNECTED__61
+ product[46]=SYNOPSYS_UNCONNECTED__62 product[45]=SYNOPSYS_UNCONNECTED__63
+ product[44]=SYNOPSYS_UNCONNECTED__64 product[43]=SYNOPSYS_UNCONNECTED__65
+ product[42]=SYNOPSYS_UNCONNECTED__66 product[41]=SYNOPSYS_UNCONNECTED__67
+ product[40]=SYNOPSYS_UNCONNECTED__68 product[39]=SYNOPSYS_UNCONNECTED__69
+ product[38]=SYNOPSYS_UNCONNECTED__70 product[37]=SYNOPSYS_UNCONNECTED__71
+ product[36]=SYNOPSYS_UNCONNECTED__72 product[35]=N870 product[34]=N869
+ product[33]=N868 product[32]=N867 product[31]=N866 product[30]=N865
+ product[29]=N864 product[28]=N863 product[27]=N862 product[26]=N861
+ product[25]=N860 product[24]=N859 product[23]=N858 product[22]=N857
+ product[21]=N856 product[20]=N855 product[19]=N854 product[18]=N853
+ product[17]=N852 product[16]=N851 product[15]=N850 product[14]=N849
+ product[13]=N848 product[12]=N847 product[11]=N846 product[10]=N845
+ product[9]=N844 product[8]=N843 product[7]=N842 product[6]=N841 product[5]=N840
+ product[4]=N839 product[3]=N838 product[2]=FE_UNCONNECTEDZ_148
+ product[1]=SYNOPSYS_UNCONNECTED__73 product[0]=SYNOPSYS_UNCONNECTED__74
+ p1=N1281 FE_OFN5835_N1281=FE_OFN5835_N1281
Xr2263 CONV_DW01_add_37 $PINS A[35]=N1653 A[34]=N1652 A[33]=N1651 A[32]=N1650
+ A[31]=N1649 A[30]=N1648 A[29]=N1647 A[28]=N1646 A[27]=N1645 A[26]=N1644
+ A[25]=N1643 A[24]=N1642 A[23]=N1641 A[22]=N1640 A[21]=N1639 A[20]=N1638
+ A[19]=N1637 A[18]=N1636 A[17]=N1635 A[16]=N1634 A[15]=N1633 A[14]=N1632
+ A[13]=N1631 A[12]=N1630 A[11]=N1629 A[10]=N1628 A[9]=N1627 A[8]=N1626
+ A[7]=N1625 A[6]=N1624 A[5]=N1623 A[4]=N1622 A[3]=N1621 A[2]=N1620 A[1]=N1619
+ A[0]=FE_DBTN1180_N1618 B[35]=N1746 B[34]=N1745 B[33]=N1744 B[32]=n6662
+ B[31]=N1742 B[30]=N1741 B[29]=N1740 B[28]=N1739 B[27]=N1738 B[26]=N1737
+ B[25]=N1736 B[24]=N1735 B[23]=N1734 B[22]=N1733 B[21]=N1732 B[20]=N1731
+ B[19]=N1730 B[18]=n6661 B[17]=N1728 B[16]=n6660 B[15]=N1726 B[14]=N1725
+ B[13]=N1724 B[12]=N1723 B[11]=N1722 B[10]=N1721 B[9]=N1720 B[8]=N1719
+ B[7]=N1718 B[6]=N1717 B[5]=N1716 B[4]=N1715 B[3]=N1714 B[2]=N1713 B[1]=N1712
+ B[0]=FE_OFN5848_FE_DBTN21_N1711 SUM[35]=N1782 SUM[34]=N1781 SUM[33]=N1780
+ SUM[32]=N1779 SUM[31]=N1778 SUM[30]=N1777 SUM[29]=N1776 SUM[28]=N1775
+ SUM[27]=N1774 SUM[26]=N1773 SUM[25]=N1772 SUM[24]=N1771 SUM[23]=N1770
+ SUM[22]=N1769 SUM[21]=N1768 SUM[20]=N1767 SUM[19]=N1766 SUM[18]=N1765
+ SUM[17]=N1764 SUM[16]=N1763 SUM[15]=N1762 SUM[14]=N1761 SUM[13]=N1760
+ SUM[12]=N1759 SUM[11]=N1758 SUM[10]=N1757 SUM[9]=N1756 SUM[8]=N1755
+ SUM[7]=N1754 SUM[6]=N1753 SUM[5]=N1752 SUM[4]=N1751 SUM[3]=N1750 SUM[2]=N1749
+ SUM[1]=N1748 SUM[0]=N1747
Xr2264 CONV_DW01_add_38 $PINS A[35]=N1526 A[34]=N1525 A[33]=N1524 A[32]=N1523
+ A[31]=N1522 A[30]=N1521 A[29]=N1520 A[28]=N1519 A[27]=N1518 A[26]=N1517
+ A[25]=N1516 A[24]=N1515 A[23]=N1514 A[22]=N1513 A[21]=N1512 A[20]=N1511
+ A[19]=N1510 A[18]=N1509 A[17]=N1508 A[16]=N1507 A[15]=N1506 A[14]=N1505
+ A[13]=N1504 A[12]=N1503 A[11]=N1502 A[10]=N1501 A[9]=N1500 A[8]=N1499
+ A[7]=N1498 A[6]=N1497 A[5]=N1496 A[4]=N1495 A[3]=N1494 A[2]=N1493 A[1]=N1492
+ A[0]=N1491 B[35]=N1782 B[34]=N1781 B[33]=N1780 B[32]=N1779 B[31]=N1778
+ B[30]=N1777 B[29]=N1776 B[28]=N1775 B[27]=N1774 B[26]=N1773 B[25]=N1772
+ B[24]=N1771 B[23]=N1770 B[22]=N1769 B[21]=N1768 B[20]=N1767 B[19]=N1766
+ B[18]=N1765 B[17]=N1764 B[16]=N1763 B[15]=N1762 B[14]=N1761 B[13]=N1760
+ B[12]=N1759 B[11]=N1758 B[10]=N1757 B[9]=N1756 B[8]=N1755 B[7]=N1754 B[6]=N1753
+ B[5]=N1752 B[4]=N1751 B[3]=N1750 B[2]=N1749 B[1]=N1748 B[0]=N1747 SUM[35]=n97
+ SUM[34]=n98 SUM[33]=n99 SUM[32]=n100 SUM[31]=n101 SUM[30]=n102 SUM[29]=n103
+ SUM[28]=n104 SUM[27]=n105 SUM[26]=n106 SUM[25]=n107 SUM[24]=n108 SUM[23]=n109
+ SUM[22]=n110 SUM[21]=n111 SUM[20]=n112 SUM[19]=n113 SUM[18]=n114 SUM[17]=n115
+ SUM[16]=n116 SUM[15]=n117 SUM[14]=n118 SUM[13]=n119 SUM[12]=n120 SUM[11]=n121
+ SUM[10]=n122 SUM[9]=n123 SUM[8]=n124 SUM[7]=n125 SUM[6]=n126 SUM[5]=n127
+ SUM[4]=n128 SUM[3]=n129 SUM[2]=n130 SUM[1]=n131 SUM[0]=n132
Xr2244 CONV_DW01_add_39 $PINS A[35]=N941 A[34]=N940 A[33]=N939 A[32]=N938
+ A[31]=N937 A[30]=N936 A[29]=N935 A[28]=N934 A[27]=N933 A[26]=N932 A[25]=N931
+ A[24]=N930 A[23]=N929 A[22]=N928 A[21]=N927 A[20]=N926 A[19]=N925 A[18]=N924
+ A[17]=N923 A[16]=N922 A[15]=N921 A[14]=N920 A[13]=N919 A[12]=N918 A[11]=N917
+ A[10]=N916 A[9]=N915 A[8]=N914 A[7]=N913 A[6]=N912 A[5]=N911 A[4]=N910
+ A[3]=N909 A[2]=N908 A[1]=N907 A[0]=n5321 B[35]=N1069 B[34]=N1068 B[33]=N1067
+ B[32]=N1066 B[31]=N1065 B[30]=N1064 B[29]=N1063 B[28]=N1062 B[27]=N1061
+ B[26]=N1060 B[25]=N1059 B[24]=N1058 B[23]=N1057 B[22]=N1056 B[21]=N1055
+ B[20]=N1054 B[19]=N1053 B[18]=N1052 B[17]=N1051 B[16]=N1050 B[15]=N1049
+ B[14]=N1048 B[13]=N1047 B[12]=N1046 B[11]=N1045 B[10]=N1044 B[9]=N1043
+ B[8]=N1042 B[7]=N1041 B[6]=N1040 B[5]=N1039 B[4]=N1038 B[3]=N1037 B[2]=N1036
+ B[1]=N1035 B[0]=FE_OFN5728_N999 SUM[35]=N1105 SUM[34]=N1104 SUM[33]=N1103
+ SUM[32]=N1102 SUM[31]=N1101 SUM[30]=N1100 SUM[29]=N1099 SUM[28]=N1098
+ SUM[27]=N1097 SUM[26]=N1096 SUM[25]=N1095 SUM[24]=N1094 SUM[23]=N1093
+ SUM[22]=N1092 SUM[21]=N1091 SUM[20]=N1090 SUM[19]=N1089 SUM[18]=N1088
+ SUM[17]=N1087 SUM[16]=N1086 SUM[15]=N1085 SUM[14]=N1084 SUM[13]=N1083
+ SUM[12]=N1082 SUM[11]=N1081 SUM[10]=N1080 SUM[9]=N1079 SUM[8]=N1078
+ SUM[7]=N1077 SUM[6]=N1076 SUM[5]=N1075 SUM[4]=N1074 SUM[3]=N1073 SUM[2]=N1072
+ SUM[1]=N1071 SUM[0]=N1070
Xr2239 CONV_DW01_sub_14 $PINS A[35]=N870 A[34]=N869 A[33]=N868 A[32]=N867
+ A[31]=N866 A[30]=N865 A[29]=N864 A[28]=N863 A[27]=N862 A[26]=N861 A[25]=N860
+ A[24]=N859 A[23]=N858 A[22]=N857 A[21]=N856 A[20]=N855 A[19]=N854 A[18]=N853
+ A[17]=N852 A[16]=N851 A[15]=N850 A[14]=N849 A[13]=N848 A[12]=N847 A[11]=N846
+ A[10]=N845 A[9]=N844 A[8]=N843 A[7]=N842 A[6]=N841 A[5]=N840 A[4]=N839
+ A[3]=N838 A[2]=N1315 A[1]=FE_UNCONNECTEDZ_149 A[0]=FE_UNCONNECTEDZ_150
+ B[35]=FE_UNCONNECTEDZ_151 B[34]=N905 B[33]=N904 B[32]=N903 B[31]=N902
+ B[30]=N901 B[29]=N900 B[28]=N899 B[27]=N898 B[26]=N897 B[25]=N896 B[24]=N895
+ B[23]=N894 B[22]=N893 B[21]=N892 B[20]=N891 B[19]=N890 B[18]=N889 B[17]=N888
+ B[16]=N887 B[15]=N886 B[14]=N885 B[13]=N884 B[12]=N883 B[11]=FE_DBTN186_N882
+ B[10]=N881 B[9]=N880 B[8]=N879 B[7]=N878 B[6]=N877 B[5]=N876 B[4]=N875
+ B[3]=N874 B[2]=FE_DBTN1158_n4963 B[1]=FE_OFN5600_N872 B[0]=N1455 DIFF[35]=N941
+ DIFF[34]=N940 DIFF[33]=N939 DIFF[32]=N938 DIFF[31]=N937 DIFF[30]=N936
+ DIFF[29]=N935 DIFF[28]=N934 DIFF[27]=N933 DIFF[26]=N932 DIFF[25]=N931
+ DIFF[24]=N930 DIFF[23]=N929 DIFF[22]=N928 DIFF[21]=N927 DIFF[20]=N926
+ DIFF[19]=N925 DIFF[18]=N924 DIFF[17]=N923 DIFF[16]=N922 DIFF[15]=N921
+ DIFF[14]=N920 DIFF[13]=N919 DIFF[12]=N918 DIFF[11]=N917 DIFF[10]=N916
+ DIFF[9]=N915 DIFF[8]=N914 DIFF[7]=N913 DIFF[6]=N912 DIFF[5]=N911 DIFF[4]=N910
+ DIFF[3]=N909 DIFF[2]=N908 DIFF[1]=N907 DIFF[0]=N906 p1=N1386
Xregister_reg[2][5] SDFFRHQXL $PINS SI=register[0][16] SE=FE_OFN5510_i_SCAN_EN
+ D=n1930 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[2][5]
Xregister_reg[2][0] SDFFRHQX4 $PINS SI=FE_OFN5604_a_cnt_11
+ SE=FE_OFN5510_i_SCAN_EN D=n1944 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=N567
Xregister_reg[3][10] SDFFRHQXL $PINS SI=register[3][12] SE=FE_OFN5509_i_SCAN_EN
+ D=n1845 CK=CTS_1 RN=FE_OFN5943_n Q=register[3][10]
Xregister_reg[7][0] SDFFRHQX1 $PINS SI=FE_OFN5989_register_6__13
+ SE=FE_OFN5514_i_SCAN_EN D=n1763 CK=CTS_5 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=FE_DBTN21_N1711
Xregister_reg[2][1] SDFFRHQXL $PINS SI=FE_OFN6265_CMF0_8
+ SE=FE_OFN5510_i_SCAN_EN D=n1926 CK=CTS_1 RN=FE_DBTN149_i_reset Q=register[2][1]
Xregister_reg[5][3] SDFFRHQX4 $PINS SI=FE_OFN335_register_4__9
+ SE=FE_OFN5509_i_SCAN_EN D=n1908 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][3]
Xregister_reg[2][12] SDFFRHQXL $PINS SI=FE_OFN5614_CMF0_12
+ SE=FE_OFN5512_i_SCAN_EN D=n1937 CK=CTS_1 RN=FE_OFN5634_FE_DBTN149_i_reset
+ Q=register[2][12]
Xregister_reg[2][4] SDFFRHQXL $PINS SI=n5475 SE=FE_OFN5510_i_SCAN_EN D=n1929
+ CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[2][4]
Xregister_reg[7][4] SDFFRHQX4 $PINS SI=CMF1[14] SE=FE_OFN5513_i_SCAN_EN D=n1775
+ CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[7][4]
Xregister_reg[7][8] SDFFRHQX4 $PINS SI=FE_OFN262_register_7__10
+ SE=FE_OFN5515_i_SCAN_EN D=n1787 CK=CTS_2 RN=FE_OFN5945_n Q=register[7][8]
Xregister_reg[5][0] SDFFRHQX4 $PINS SI=register[5][3] SE=FE_OFN5509_i_SCAN_EN
+ D=n1924 CK=CTS_5 RN=FE_OFN5943_n Q=N1281
Xregister_reg[7][7] SDFFRHQXL $PINS SI=CMF1[8] SE=FE_OFN5513_i_SCAN_EN D=n1784
+ CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[7][7]
Xregister_reg[0][0] SDFFRHQX2 $PINS SI=n5503 SE=FE_OFN5510_i_SCAN_EN D=n1865
+ CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=N1618
Xregister_reg[3][0] SDFFRHQX1 $PINS SI=n6723 SE=FE_OFN5509_i_SCAN_EN D=n1825
+ CK=CTS_5 RN=FE_OFN5943_n Q=n5319
Xregister_reg[5][4] SDFFRHQX4 $PINS SI=FE_OCPN6209_register_5__2
+ SE=FE_OFN5509_i_SCAN_EN D=n1909 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][4]
Xregister_reg[0][3] SDFFRHQX2 $PINS SI=n5114 SE=FE_OFN5510_i_SCAN_EN D=n1868
+ CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[0][3]
Xregister_reg[2][6] SDFFRHQXL $PINS SI=FE_OFN5539_register_2__9
+ SE=FE_OFN5510_i_SCAN_EN D=n1931 CK=CTS_1 RN=FE_DBTN149_i_reset Q=register[2][6]
Xregister_reg[8][8] SDFFRHQX1 $PINS SI=register[8][7] SE=FE_OFN5514_i_SCAN_EN
+ D=n1788 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[8][8]
Xregister_reg[5][2] SDFFRHQX4 $PINS SI=FE_OFN5824_register_4__12
+ SE=FE_OFN5509_i_SCAN_EN D=n1907 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][2]
Xregister_reg[5][1] SDFFRHQX4 $PINS SI=register[5][4] SE=FE_OFN5509_i_SCAN_EN
+ D=n1906 CK=CTS_5 RN=FE_OFN5943_n Q=N1316
Xregister_reg[3][1] SDFFRHQX4 $PINS SI=FE_OFN5775_n5319 SE=FE_OFN5509_i_SCAN_EN
+ D=n1863 CK=CTS_5 RN=FE_OFN5943_n Q=FE_OFN6039_N1177
Xregister_reg[1][5] SDFFRHQX2 $PINS SI=n5500 SE=FE_OFN5510_i_SCAN_EN D=n1890
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=register[1][5]
Xregister_reg[8][11] SDFFRHQXL $PINS SI=register[8][8] SE=FE_OFN5513_i_SCAN_EN
+ D=n1797 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[8][11]
Xregister_reg[8][19] SDFFRHQXL $PINS SI=FE_OFN5993_register_8__15
+ SE=FE_OFN5513_i_SCAN_EN D=n1821 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[8][19]
Xregister_reg[1][3] SDFFRHQX1 $PINS SI=FE_OFN5526_register_1__7
+ SE=FE_OFN5510_i_SCAN_EN D=n1888 CK=CTS_1 RN=FE_DBTN149_i_reset Q=register[1][3]
Xregister_reg[8][10] SDFFRHQXL $PINS SI=FE_OFN6036_register_8__11
+ SE=FE_OFN5513_i_SCAN_EN D=n1794 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[8][10]
Xregister_reg[7][1] SDFFRHQX4 $PINS SI=register[6][10] SE=FE_OFN5514_i_SCAN_EN
+ D=n1766 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[7][1]
Xregister_reg[1][16] SDFFRHQXL $PINS SI=FE_OFN6019_register_0__11
+ SE=FE_OFN5510_i_SCAN_EN D=n1901 CK=CTS_1 RN=FE_DBTN149_i_reset
+ Q=register[1][16]
Xregister_reg[4][5] SDFFRHQXL $PINS SI=register[4][4] SE=FE_OFN5509_i_SCAN_EN
+ D=n1836 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][5]
Xregister_reg[2][13] SDFFRHQXL $PINS SI=FE_OFN5538_register_2__10
+ SE=FE_OFN5512_i_SCAN_EN D=n1938 CK=CTS_1 RN=FE_OFN5948_n Q=register[2][13]
XCMF1_reg[33] SDFFRHQXL $PINS SI=CMF1[32] SE=FE_OFN5515_i_SCAN_EN D=n4912
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[33]
XCMF1_reg[34] SDFFRHQXL $PINS SI=cdata_wr[2] SE=FE_OFN5515_i_SCAN_EN D=n4935
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[34]
XCMF1_reg[35] SDFFRHQXL $PINS SI=CMF1[34] SE=FE_OFN5515_i_SCAN_EN D=n4940
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[35]
XCMF1_reg[31] SDFFRHQXL $PINS SI=CMF1[30] SE=FE_OFN5515_i_SCAN_EN D=n5145
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[31]
XCMF0_reg[31] SDFFRHQXL $PINS SI=CMF0[30] SE=FE_OFN5512_i_SCAN_EN D=n5126
+ CK=CTS_4 RN=FE_OFN5948_n Q=CMF0[31]
Xregister_reg[1][0] SDFFRHQX1 $PINS SI=N15861 SE=FE_OFN5510_i_SCAN_EN D=n1885
+ CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[1][0]
Xregister_reg[0][8] SDFFRHQX4 $PINS SI=FE_OFN5524_register_1__9
+ SE=FE_OFN5510_i_SCAN_EN D=n1873 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[0][8]
Xregister_reg[7][2] SDFFRHQX4 $PINS SI=FE_OFN5579_register_7__13
+ SE=FE_OFN5513_i_SCAN_EN D=n1769 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[7][2]
Xregister_reg[7][3] SDFFRHQX4 $PINS SI=register[7][2] SE=FE_OFN5513_i_SCAN_EN
+ D=n1772 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[7][3]
Xregister_reg[7][6] SDFFRHQX4 $PINS SI=register[6][16] SE=FE_OFN5515_i_SCAN_EN
+ D=n1781 CK=CTS_2 RN=FE_OFN5945_n Q=register[7][6]
Xregister_reg[7][9] SDFFRHQX1 $PINS SI=register[7][6] SE=FE_OFN5515_i_SCAN_EN
+ D=n1790 CK=CTS_2 RN=FE_OFN5945_n Q=register[7][9]
Xregister_reg[7][11] SDFFRHQX2 $PINS SI=FE_OFN5896_register_7__7
+ SE=FE_OFN5513_i_SCAN_EN D=n1796 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[7][11]
Xregister_reg[3][12] SDFFRHQX4 $PINS SI=N609 SE=FE_OFN5509_i_SCAN_EN D=n1849
+ CK=CTS_1 RN=FE_OFN5943_n Q=register[3][12]
Xregister_reg[2][10] SDFFRHQXL $PINS SI=FE_OFN5537_register_2__11
+ SE=FE_OFN5512_i_SCAN_EN D=n1935 CK=CTS_1 RN=FE_OFN5948_n Q=register[2][10]
Xregister_reg[8][9] SDFFRHQXL $PINS SI=register[8][10] SE=FE_OFN5513_i_SCAN_EN
+ D=n1791 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[8][9]
Xregister_reg[1][4] SDFFRX4 $PINS SI=FE_OFN5528_register_1__3
+ SE=FE_OFN5510_i_SCAN_EN D=n1889 CK=CTS_1 RN=FE_DBTN149_i_reset Q=register[1][4]
+ QN=n5500
Xregister_reg[0][10] SDFFRX4 $PINS SI=FE_OFN5611_CMF0_15
+ SE=FE_OFN5512_i_SCAN_EN D=n1875 CK=CTS_1 RN=FE_OFN5634_FE_DBTN149_i_reset
+ Q=register[0][10] QN=n5765
Xregister_reg[1][1] SDFFRX4 $PINS SI=FE_OFN5998_register_1__0
+ SE=FE_OFN5510_i_SCAN_EN D=n1886 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[1][1] QN=n5504
Xregister_reg[1][2] SDFFRX4 $PINS SI=n5504 SE=FE_OFN5510_i_SCAN_EN D=n1887
+ CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[1][2] QN=n5502
Xregister_reg[0][1] SDFFRX4 $PINS SI=FE_OFN5761_register_0__3
+ SE=FE_OFN5510_i_SCAN_EN D=n1866 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[0][1] QN=n5503
Xregister_reg[0][4] SDFFRX4 $PINS SI=FE_OFN5541_register_2__7
+ SE=FE_OFN5510_i_SCAN_EN D=n1869 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[0][4] QN=n5760
XCMF0_reg[29] SDFFRHQXL $PINS SI=CMF0[28] SE=FE_OFN5512_i_SCAN_EN D=n5016
+ CK=CTS_4 RN=FE_OFN5948_n Q=CMF0[29]
XCMF0_reg[30] SDFFRHQXL $PINS SI=CMF0[29] SE=FE_OFN5512_i_SCAN_EN D=n5120
+ CK=CTS_4 RN=FE_OFN5948_n Q=CMF0[30]
XCMF1_reg[29] SDFFRHQXL $PINS SI=CMF1[31] SE=FE_OFN5515_i_SCAN_EN D=n5017
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[29]
XCMF1_reg[30] SDFFRHQXL $PINS SI=cdata_wr[15] SE=FE_OFN5515_i_SCAN_EN D=n5012
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[30]
XCMF1_reg[27] SDFFRHQXL $PINS SI=cdata_wr[14] SE=FE_OFN5515_i_SCAN_EN D=n6763
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[27]
XCMF1_reg[28] SDFFRHQXL $PINS SI=cdata_wr[13] SE=FE_OFN5515_i_SCAN_EN D=n4936
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[28]
XCMF1_reg[32] SDFFRHQXL $PINS SI=CMF1[29] SE=FE_OFN5515_i_SCAN_EN D=n5151
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[32]
Xregister_reg[2][3] SDFFRX4 $PINS SI=n5760 SE=FE_OFN5510_i_SCAN_EN D=n1928
+ CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[2][3] QN=n5475
Xcaddr_wr_reg[0] SDFFRHQXL $PINS SI=caddr_wr[3] SE=FE_OFN5512_i_SCAN_EN D=n3673
+ CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN5472_i_caddr_wr_0
Xcaddr_wr_reg[11] SDFFRHQXL $PINS SI=caddr_wr[10] SE=FE_OFN5512_i_SCAN_EN
+ D=n3671 CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN5462_i_caddr_wr_11
Xcaddr_wr_reg[10] SDFFRHQXL $PINS SI=caddr_wr[8] SE=FE_OFN5512_i_SCAN_EN
+ D=n3636 CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN5463_i_caddr_wr_10
Xcaddr_wr_reg[9] SDFFRHQXL $PINS SI=caddr_wr[11] SE=FE_OFN5512_i_SCAN_EN
+ D=n3638 CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN5464_i_caddr_wr_9
Xcaddr_wr_reg[8] SDFFRHQXL $PINS SI=caddr_wr[7] SE=FE_OFN5512_i_SCAN_EN D=n3640
+ CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN6264_i_caddr_wr_8
Xcaddr_wr_reg[7] SDFFRHQXL $PINS SI=caddr_wr[6] SE=FE_OFN5512_i_SCAN_EN D=n3642
+ CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN5465_i_caddr_wr_7
Xcaddr_wr_reg[6] SDFFRHQXL $PINS SI=caddr_wr[0] SE=FE_OFN5512_i_SCAN_EN D=n3644
+ CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN5466_i_caddr_wr_6
Xcaddr_wr_reg[5] SDFFRHQXL $PINS SI=caddr_wr[4] SE=FE_OFN5512_i_SCAN_EN D=n3646
+ CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN5467_i_caddr_wr_5
Xcaddr_wr_reg[4] SDFFRHQXL $PINS SI=N14813 SE=FE_OFN5512_i_SCAN_EN D=n3648
+ CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN5468_i_caddr_wr_4
Xcaddr_wr_reg[3] SDFFRHQXL $PINS SI=caddr_wr[2] SE=FE_OFN5512_i_SCAN_EN D=n3650
+ CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN5469_i_caddr_wr_3
Xcaddr_wr_reg[2] SDFFRHQXL $PINS SI=caddr_wr[1] SE=FE_OFN5512_i_SCAN_EN D=n3635
+ CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN5470_i_caddr_wr_2
Xcaddr_wr_reg[1] SDFFRHQXL $PINS SI=caddr_wr[5] SE=FE_OFN5512_i_SCAN_EN D=n3670
+ CK=CTS_4 RN=FE_OFN5948_n Q=FE_OFN5471_i_caddr_wr_1
Xiaddr_reg[0] SDFFRHQXL $PINS SI=iaddr[5] SE=FE_OFN5510_i_SCAN_EN D=n3697
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=FE_OFN5460_i_iaddr_0
Xcaddr_rd_reg[0] SDFFRHQXL $PINS SI=caddr_rd[1] SE=FE_OFN5515_i_SCAN_EN D=n3685
+ CK=CTS_2 RN=FE_OFN5945_n Q=FE_OFN5505_i_caddr_rd_0
Xiaddr_reg[11] SDFFRHQXL $PINS SI=iaddr[0] SE=FE_OFN5510_i_SCAN_EN D=n3696
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=FE_OFN5449_i_iaddr_11
Xcaddr_rd_reg[11] SDFFRHQXL $PINS SI=FE_OFN5598_N8548 SE=FE_OFN5513_i_SCAN_EN
+ D=n3684 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=FE_OFN5494_i_caddr_rd_11
Xiaddr_reg[10] SDFFRHQXL $PINS SI=FE_OFN6029_register_1__17
+ SE=FE_OFN5510_i_SCAN_EN D=n3695 CK=CTS_1 RN=FE_DBTN149_i_reset
+ Q=FE_OFN5450_i_iaddr_10
Xcaddr_rd_reg[10] SDFFRHQXL $PINS SI=caddr_rd[7] SE=FE_OFN5514_i_SCAN_EN
+ D=n3683 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=FE_OFN5495_i_caddr_rd_10
Xiaddr_reg[9] SDFFRHQXL $PINS SI=FE_OFN5523_register_1__13
+ SE=FE_OFN5510_i_SCAN_EN D=n3694 CK=CTS_1 RN=FE_DBTN149_i_reset
+ Q=FE_OFN5451_i_iaddr_9
Xcaddr_rd_reg[9] SDFFRHQXL $PINS SI=caddr_rd[10] SE=FE_OFN5514_i_SCAN_EN
+ D=n3682 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=FE_OFN5496_i_caddr_rd_9
Xiaddr_reg[8] SDFFRHQXL $PINS SI=iaddr[7] SE=FE_OFN5510_i_SCAN_EN D=n3693
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=FE_OFN5452_i_iaddr_8
Xcaddr_rd_reg[8] SDFFRHQXL $PINS SI=caddr_rd[6] SE=FE_OFN5514_i_SCAN_EN D=n3681
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=FE_OFN5497_i_caddr_rd_8
Xiaddr_reg[7] SDFFRHQXL $PINS SI=iaddr[9] SE=FE_OFN5510_i_SCAN_EN D=n3692
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=FE_OFN5453_i_iaddr_7
Xcaddr_rd_reg[7] SDFFRHQXL $PINS SI=caddr_rd[8] SE=FE_OFN5514_i_SCAN_EN D=n3680
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=FE_OFN5498_i_caddr_rd_7
Xiaddr_reg[2] SDFFRHQXL $PINS SI=iaddr[6] SE=FE_OFN5509_i_SCAN_EN D=n3690
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=FE_OFN5458_i_iaddr_2
Xcaddr_rd_reg[2] SDFFRHQXL $PINS SI=csel[0] SE=FE_OFN5515_i_SCAN_EN D=n3678
+ CK=CTS_2 RN=FE_OFN5945_n Q=FE_OFN5503_i_caddr_rd_2
Xiaddr_reg[3] SDFFRHQXL $PINS SI=FE_OFN5589_N607 SE=FE_OFN5509_i_SCAN_EN
+ D=n3689 CK=CTS_1 RN=FE_DBTN149_i_reset Q=FE_OFN5457_i_iaddr_3
Xcaddr_rd_reg[3] SDFFRHQXL $PINS SI=FE_OFN5596_N8546 SE=FE_OFN5515_i_SCAN_EN
+ D=n3677 CK=CTS_2 RN=FE_OFN5945_n Q=FE_OFN5502_i_caddr_rd_3
Xiaddr_reg[4] SDFFRHQXL $PINS SI=iaddr[2] SE=FE_OFN5509_i_SCAN_EN D=n3688
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=FE_OFN5456_i_iaddr_4
Xcaddr_rd_reg[4] SDFFRHQXL $PINS SI=caddr_rd[3] SE=FE_OFN5513_i_SCAN_EN D=n3676
+ CK=CTS_2 RN=FE_OFN5945_n Q=FE_OFN5501_i_caddr_rd_4
Xiaddr_reg[5] SDFFRHQXL $PINS SI=iaddr[3] SE=FE_OFN5509_i_SCAN_EN D=n3687
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=FE_OFN5455_i_iaddr_5
Xcaddr_rd_reg[5] SDFFRHQXL $PINS SI=FE_OFN5597_N8547 SE=FE_OFN5513_i_SCAN_EN
+ D=n3675 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=FE_OFN5500_i_caddr_rd_5
Xiaddr_reg[6] SDFFRHQXL $PINS SI=SCAN_IN SE=FE_OFN5509_i_SCAN_EN D=n3686
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=FE_OFN5454_i_iaddr_6
Xcaddr_rd_reg[6] SDFFRHQXL $PINS SI=FE_OFN5631_CMF1_0 SE=FE_OFN5514_i_SCAN_EN
+ D=n3674 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=FE_OFN5499_i_caddr_rd_6
Xcsel_reg[0] SDFFRHQXL $PINS SI=csel[1] SE=FE_OFN5515_i_SCAN_EN D=n1824
+ CK=CTS_2 RN=FE_OFN5945_n Q=FE_OFN5508_i_csel_0
Xcsel_reg[2] SDFFRHQXL $PINS SI=crd SE=FE_OFN5515_i_SCAN_EN D=n1823 CK=CTS_2
+ RN=FE_OFN5945_n Q=FE_OFN5506_i_csel_2
Xcsel_reg[1] SDFFRHQXL $PINS SI=csel[2] SE=FE_OFN5515_i_SCAN_EN D=n1822
+ CK=CTS_2 RN=FE_OFN5945_n Q=FE_OFN5507_i_csel_1
Xcdata_wr_reg[19] SDFFRHQXL $PINS SI=cdata_wr[3] SE=FE_OFN5515_i_SCAN_EN
+ D=n3669 CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5473_i_cdata_wr_19
Xcdata_wr_reg[18] SDFFRHQXL $PINS SI=cdata_wr[17] SE=FE_OFN5515_i_SCAN_EN
+ D=n3668 CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5474_i_cdata_wr_18
Xcdata_wr_reg[17] SDFFRHQXL $PINS SI=cdata_wr[16] SE=FE_OFN5515_i_SCAN_EN
+ D=n3667 CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5475_i_cdata_wr_17
Xcdata_wr_reg[16] SDFFRHQXL $PINS SI=CMF1[33] SE=FE_OFN5515_i_SCAN_EN D=n3666
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5476_i_cdata_wr_16
Xcdata_wr_reg[15] SDFFRHQXL $PINS SI=CMF1[28] SE=FE_OFN5515_i_SCAN_EN D=n3665
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5477_i_cdata_wr_15
Xcdata_wr_reg[14] SDFFRHQXL $PINS SI=cdata_wr[12] SE=FE_OFN5515_i_SCAN_EN
+ D=n3664 CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5478_i_cdata_wr_14
Xcdata_wr_reg[13] SDFFRHQXL $PINS SI=CMF1[27] SE=FE_OFN5515_i_SCAN_EN D=n3663
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5479_i_cdata_wr_13
Xcdata_wr_reg[12] SDFFRHQXL $PINS SI=CMF1[26] SE=FE_OFN5515_i_SCAN_EN D=n3662
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5480_i_cdata_wr_12
Xcdata_wr_reg[11] SDFFRHQXL $PINS SI=cdata_wr[10] SE=FE_OFN5515_i_SCAN_EN
+ D=n3661 CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5481_i_cdata_wr_11
Xcdata_wr_reg[10] SDFFRHQXL $PINS SI=CMF1[24] SE=FE_OFN5515_i_SCAN_EN D=n3660
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5482_i_cdata_wr_10
Xcwr_reg SDFFRHQXL $PINS SI=r_cnt[1] SE=FE_OFN5512_i_SCAN_EN D=n1949 CK=CTS_4
+ RN=FE_OFN5948_n Q=FE_OFN5461_i_cwr
Xcrd_reg SDFFRHQXL $PINS SI=CMF1[16] SE=FE_OFN5515_i_SCAN_EN D=n1950 CK=CTS_2
+ RN=FE_OFN5945_n Q=FE_OFN5493_i_crd
Xiaddr_reg[1] SDFFRHQXL $PINS SI=caddr_rd[11] SE=FE_OFN5509_i_SCAN_EN D=n6665
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=FE_OFN5459_i_iaddr_1
Xcaddr_rd_reg[1] SDFFRHQXL $PINS SI=register[7][8] SE=FE_OFN5515_i_SCAN_EN
+ D=n6666 CK=CTS_2 RN=FE_OFN5945_n Q=FE_OFN5504_i_caddr_rd_1
Xcdata_wr_reg[0] SDFFRHQXL $PINS SI=cdata_wr[19] SE=FE_OFN5515_i_SCAN_EN
+ D=n3672 CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5492_i_cdata_wr_0
Xcdata_wr_reg[9] SDFFRHQXL $PINS SI=cdata_wr[8] SE=FE_OFN5515_i_SCAN_EN D=n3659
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5483_i_cdata_wr_9
Xcdata_wr_reg[8] SDFFRHQXL $PINS SI=cdata_wr[11] SE=FE_OFN5515_i_SCAN_EN
+ D=n3658 CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5484_i_cdata_wr_8
Xcdata_wr_reg[7] SDFFRHQXL $PINS SI=CMF1[23] SE=FE_OFN5515_i_SCAN_EN D=n3657
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5485_i_cdata_wr_7
Xcdata_wr_reg[6] SDFFRHQXL $PINS SI=cdata_wr[4] SE=FE_OFN5515_i_SCAN_EN D=n3656
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5486_i_cdata_wr_6
Xcdata_wr_reg[5] SDFFRHQXL $PINS SI=cdata_wr[6] SE=FE_OFN5515_i_SCAN_EN D=n3655
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5487_i_cdata_wr_5
Xcdata_wr_reg[4] SDFFRHQXL $PINS SI=c_cnt[11] SE=FE_OFN5515_i_SCAN_EN D=n3654
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5488_i_cdata_wr_4
Xcdata_wr_reg[3] SDFFRHQXL $PINS SI=CMF1[35] SE=FE_OFN5515_i_SCAN_EN D=n3653
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5489_i_cdata_wr_3
Xcdata_wr_reg[2] SDFFRHQXL $PINS SI=cdata_wr[1] SE=FE_OFN5515_i_SCAN_EN D=n3652
+ CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5490_i_cdata_wr_2
Xcdata_wr_reg[1] SDFFRHQXL $PINS SI=cdata_wr[18] SE=FE_OFN5515_i_SCAN_EN
+ D=n3651 CK=CTS_4 RN=FE_OFN5945_n Q=FE_OFN5491_i_cdata_wr_1
Xa_cnt_reg[12] SDFFRHQXL $PINS SI=FE_DBTN1180_N1618 SE=FE_OFN5510_i_SCAN_EN
+ D=n1758 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=a_cnt[12]
Xa_cnt_reg[11] SDFFRHQXL $PINS SI=FE_OFN5605_a_cnt_10 SE=FE_OFN5510_i_SCAN_EN
+ D=n1757 CK=CTS_2 RN=FE_OFN5633_FE_DBTN149_i_reset Q=a_cnt[11]
Xa_cnt_reg[7] SDFFRHQXL $PINS SI=iaddr[1] SE=FE_OFN5510_i_SCAN_EN D=n1745
+ CK=CTS_2 RN=FE_OFN5633_FE_DBTN149_i_reset Q=a_cnt[7]
Xa_cnt_reg[10] SDFFRHQXL $PINS SI=FE_OFN5607_a_cnt_8 SE=FE_OFN5510_i_SCAN_EN
+ D=n1754 CK=CTS_2 RN=FE_OFN5633_FE_DBTN149_i_reset Q=a_cnt[10]
Xcnt_flag_reg SDFFRHQXL $PINS SI=CMF0[24] SE=FE_OFN5512_i_SCAN_EN D=n2001
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14832
Xa_cnt_reg[8] SDFFRHQXL $PINS SI=FE_OFN5609_a_cnt_6 SE=FE_OFN5510_i_SCAN_EN
+ D=n1748 CK=CTS_2 RN=FE_OFN5633_FE_DBTN149_i_reset Q=a_cnt[8]
Xa_cnt_reg[9] SDFFRHQXL $PINS SI=FE_OFN5608_a_cnt_7 SE=FE_OFN5510_i_SCAN_EN
+ D=n1751 CK=CTS_2 RN=FE_OFN5633_FE_DBTN149_i_reset Q=a_cnt[9]
Xa_cnt_reg[1] SDFFRHQXL $PINS SI=caddr_rd[2] SE=FE_OFN5515_i_SCAN_EN D=n1742
+ CK=CTS_2 RN=FE_OFN5945_n Q=N8545
Xa_cnt_reg[2] SDFFRHQXL $PINS SI=N8545 SE=FE_OFN5515_i_SCAN_EN D=n1739 CK=CTS_2
+ RN=FE_OFN5945_n Q=N8546
Xa_cnt_reg[4] SDFFRHQXL $PINS SI=caddr_rd[9] SE=FE_OFN5513_i_SCAN_EN D=n1733
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=N8548
Xa_cnt_reg[5] SDFFRHQXL $PINS SI=caddr_rd[4] SE=FE_OFN5513_i_SCAN_EN D=n1730
+ CK=CTS_2 RN=FE_OFN5633_FE_DBTN149_i_reset Q=N8549
Xa_cnt_reg[3] SDFFRHQXL $PINS SI=FE_OFN5599_N8549 SE=FE_OFN5513_i_SCAN_EN
+ D=n1736 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=N8547
XCMF0_reg[0] SDFFRHQXL $PINS SI=FE_OFN5532_register_2__16
+ SE=FE_OFN5512_i_SCAN_EN D=n1688 CK=CTS_1 RN=FE_OFN5948_n Q=CMF0[0]
XCMF1_reg[0] SDFFRHQXL $PINS SI=CMF1[9] SE=FE_OFN5514_i_SCAN_EN D=n1724
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=CMF1[0]
XCMF0_reg[10] SDFFRHQXL $PINS SI=FE_OFN5787_register_2__6
+ SE=FE_OFN5510_i_SCAN_EN D=n1662 CK=CTS_1 RN=FE_DBTN149_i_reset Q=CMF0[10]
XCMF1_reg[10] SDFFRHQXL $PINS SI=CMF1[13] SE=FE_OFN5513_i_SCAN_EN D=n1698
+ CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=CMF1[10]
XCMF1_reg[4] SDFFRHQXL $PINS SI=caddr_rd[5] SE=FE_OFN5513_i_SCAN_EN D=n1692
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=CMF1[4]
XCMF0_reg[8] SDFFRHQXL $PINS SI=FE_OFN5531_register_2__17
+ SE=FE_OFN5510_i_SCAN_EN D=n1660 CK=CTS_1 RN=FE_DBTN149_i_reset Q=CMF0[8]
XCMF0_reg[4] SDFFRHQXL $PINS SI=FE_OFN5533_register_2__15
+ SE=FE_OFN5512_i_SCAN_EN D=n1656 CK=CTS_1 RN=FE_OFN5948_n Q=CMF0[4]
XCMF1_reg[8] SDFFRHQXL $PINS SI=CMF1[6] SE=FE_OFN5513_i_SCAN_EN D=n1696
+ CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=CMF1[8]
XCMF0_reg[13] SDFFRHQXL $PINS SI=FE_OFN5612_CMF0_14 SE=FE_OFN5510_i_SCAN_EN
+ D=n1665 CK=CTS_1 RN=FE_DBTN149_i_reset Q=CMF0[13]
XCMF1_reg[13] SDFFRHQXL $PINS SI=register[7][4] SE=FE_OFN5513_i_SCAN_EN D=n1701
+ CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=CMF1[13]
XCMF0_reg[12] SDFFRHQXL $PINS SI=FE_OFN5615_CMF0_11 SE=FE_OFN5512_i_SCAN_EN
+ D=n1664 CK=CTS_1 RN=FE_OFN5948_n Q=CMF0[12]
XCMF1_reg[12] SDFFRHQXL $PINS SI=register[7][1] SE=FE_OFN5513_i_SCAN_EN D=n1700
+ CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=CMF1[12]
XCMF0_reg[27] SDFFRHQXL $PINS SI=CMF0[26] SE=FE_OFN5512_i_SCAN_EN D=n5015
+ CK=CTS_4 RN=FE_OFN5948_n Q=CMF0[27]
XCMF0_reg[26] SDFFRHQXL $PINS SI=CMF0[25] SE=FE_OFN5512_i_SCAN_EN D=n1676
+ CK=CTS_4 RN=FE_OFN5948_n Q=CMF0[26]
XCMF0_reg[28] SDFFRHQXL $PINS SI=CMF0[27] SE=FE_OFN5512_i_SCAN_EN D=n5014
+ CK=CTS_4 RN=FE_OFN5948_n Q=CMF0[28]
XCMF0_reg[19] SDFFRHQXL $PINS SI=CMF0[18] SE=FE_OFN5512_i_SCAN_EN D=n1686
+ CK=CTS_2 RN=FE_OFN5948_n Q=CMF0[19]
XCMF0_reg[23] SDFFRHQXL $PINS SI=CMF0[22] SE=FE_OFN5512_i_SCAN_EN D=n4870
+ CK=CTS_4 RN=FE_OFN5948_n Q=CMF0[23]
XCMF0_reg[14] SDFFRHQXL $PINS SI=FE_OFN5617_CMF0_9 SE=FE_OFN5510_i_SCAN_EN
+ D=n1666 CK=CTS_1 RN=FE_DBTN149_i_reset Q=CMF0[14]
XCMF1_reg[14] SDFFRHQXL $PINS SI=register[7][11] SE=FE_OFN5513_i_SCAN_EN
+ D=n1702 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=CMF1[14]
XCMF1_reg[26] SDFFRHQXL $PINS SI=CMF1[25] SE=FE_OFN5515_i_SCAN_EN D=n2274
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[26]
XCMF0_reg[25] SDFFRHQXL $PINS SI=N14832 SE=FE_OFN5512_i_SCAN_EN D=n4869
+ CK=CTS_4 RN=FE_OFN5948_n Q=CMF0[25]
XCMF0_reg[21] SDFFRHQXL $PINS SI=CMF0[20] SE=FE_OFN5512_i_SCAN_EN D=n4872
+ CK=CTS_4 RN=FE_OFN5948_n Q=CMF0[21]
XCMF0_reg[24] SDFFRHQXL $PINS SI=CMF0[23] SE=FE_OFN5512_i_SCAN_EN D=n2281
+ CK=CTS_4 RN=FE_OFN5948_n Q=CMF0[24]
XCMF0_reg[22] SDFFRHQXL $PINS SI=CMF0[21] SE=FE_OFN5512_i_SCAN_EN D=n4871
+ CK=CTS_4 RN=FE_OFN5948_n Q=CMF0[22]
XCMF0_reg[20] SDFFRHQXL $PINS SI=cwr SE=FE_OFN5512_i_SCAN_EN D=n4873 CK=CTS_4
+ RN=FE_OFN5948_n Q=CMF0[20]
XCMF1_reg[5] SDFFRHQXL $PINS SI=register[5][18] SE=FE_OFN5514_i_SCAN_EN D=n1693
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=CMF1[5]
XCMF1_reg[23] SDFFRHQXL $PINS SI=CMF1[22] SE=FE_OFN5515_i_SCAN_EN D=n4880
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[23]
XCMF1_reg[25] SDFFRHQXL $PINS SI=cdata_wr[9] SE=FE_OFN5515_i_SCAN_EN D=n4878
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[25]
XCMF1_reg[21] SDFFRHQXL $PINS SI=CMF1[20] SE=FE_OFN5515_i_SCAN_EN D=n4882
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[21]
XCMF1_reg[22] SDFFRHQXL $PINS SI=CMF1[21] SE=FE_OFN5515_i_SCAN_EN D=n4881
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[22]
XCMF1_reg[24] SDFFRHQXL $PINS SI=cdata_wr[7] SE=FE_OFN5515_i_SCAN_EN D=n4879
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[24]
XCMF1_reg[20] SDFFRHQXL $PINS SI=cdata_wr[5] SE=FE_OFN5515_i_SCAN_EN D=n4883
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[20]
Xbusy_reg SDFFRHQXL $PINS SI=FE_OFN5606_a_cnt_9 SE=FE_OFN5510_i_SCAN_EN D=n1983
+ CK=CTS_2 RN=FE_OFN5633_FE_DBTN149_i_reset Q=FE_OFN5448_i_busy
XCMF0_reg[11] SDFFRHQXL $PINS SI=FE_OFN5613_CMF0_13 SE=FE_OFN5510_i_SCAN_EN
+ D=n1663 CK=CTS_1 RN=FE_DBTN149_i_reset Q=CMF0[11]
XCMF1_reg[11] SDFFRHQXL $PINS SI=CMF1[10] SE=FE_OFN5513_i_SCAN_EN D=n1699
+ CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=CMF1[11]
XCMF1_reg[6] SDFFRHQXL $PINS SI=CMF1[7] SE=FE_OFN5513_i_SCAN_EN D=n1694
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=CMF1[6]
XCMF1_reg[1] SDFFRHQXL $PINS SI=CMF1[11] SE=FE_OFN5514_i_SCAN_EN D=n1689
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=CMF1[1]
XCMF0_reg[6] SDFFRHQXL $PINS SI=CMF0[7] SE=FE_OFN5510_i_SCAN_EN D=n1658
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=CMF0[6]
XCMF0_reg[1] SDFFRHQXL $PINS SI=FE_OFN5530_register_2__18
+ SE=FE_OFN5512_i_SCAN_EN D=n1653 CK=CTS_1 RN=FE_DBTN149_i_reset Q=CMF0[1]
XCMF1_reg[7] SDFFRHQXL $PINS SI=CMF1[4] SE=FE_OFN5513_i_SCAN_EN D=n1695
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=CMF1[7]
XCMF0_reg[7] SDFFRHQXL $PINS SI=CMF0[1] SE=FE_OFN5510_i_SCAN_EN D=n1659
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=CMF0[7]
XCMF0_reg[3] SDFFRHQXL $PINS SI=register[1][2] SE=FE_OFN5510_i_SCAN_EN D=n1655
+ CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=CMF0[3]
XCMF1_reg[3] SDFFRHQXL $PINS SI=n4963 SE=FE_OFN5514_i_SCAN_EN D=n1691 CK=CTS_5
+ RN=FE_OFN5633_FE_DBTN149_i_reset Q=CMF1[3]
XCMF0_reg[15] SDFFRHQXL $PINS SI=FE_OFN5535_register_2__13
+ SE=FE_OFN5512_i_SCAN_EN D=n1687 CK=CTS_1 RN=FE_OFN5948_n Q=CMF0[15]
XCMF0_reg[5] SDFFRHQXL $PINS SI=n5765 SE=FE_OFN5512_i_SCAN_EN D=n1657 CK=CTS_1
+ RN=FE_OFN5634_FE_DBTN149_i_reset Q=CMF0[5]
XCMF0_reg[9] SDFFRHQXL $PINS SI=FE_OFN5616_CMF0_10 SE=FE_OFN5510_i_SCAN_EN
+ D=n1661 CK=CTS_1 RN=FE_DBTN149_i_reset Q=CMF0[9]
XCMF1_reg[15] SDFFRHQXL $PINS SI=CMF1[12] SE=FE_OFN5513_i_SCAN_EN D=n1723
+ CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=CMF1[15]
XCMF0_reg[18] SDFFRHQXL $PINS SI=FE_OFN5529_register_2__19
+ SE=FE_OFN5512_i_SCAN_EN D=n1669 CK=CTS_2 RN=FE_OFN5948_n Q=CMF0[18]
XCMF0_reg[17] SDFFRHQXL $PINS SI=CMF0[16] SE=FE_OFN5512_i_SCAN_EN D=n1668
+ CK=CTS_2 RN=FE_OFN5948_n Q=CMF0[17]
XCMF0_reg[2] SDFFRHQXL $PINS SI=FE_OFN5620_CMF0_5 SE=FE_OFN5510_i_SCAN_EN
+ D=n1654 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=CMF0[2]
XCMF1_reg[9] SDFFRHQXL $PINS SI=CMF1[1] SE=FE_OFN5514_i_SCAN_EN D=n1697
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=CMF1[9]
XCMF1_reg[19] SDFFRHQXL $PINS SI=cdata_wr[0] SE=FE_OFN5515_i_SCAN_EN D=n1722
+ CK=CTS_4 RN=FE_OFN5945_n Q=CMF1[19]
XCMF1_reg[2] SDFFRHQXL $PINS SI=FE_OFN5600_N872 SE=FE_OFN5514_i_SCAN_EN D=n1690
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=CMF1[2]
XCMF1_reg[18] SDFFRHQXL $PINS SI=CMF1[19] SE=FE_OFN5515_i_SCAN_EN D=n1705
+ CK=CTS_2 RN=FE_OFN5945_n Q=CMF1[18]
XCMF1_reg[17] SDFFRHQXL $PINS SI=CMF1[18] SE=FE_OFN5515_i_SCAN_EN D=n1704
+ CK=CTS_2 RN=FE_OFN5945_n Q=CMF1[17]
XCMF0_reg[16] SDFFRHQXL $PINS SI=flag[1] SE=FE_OFN5512_i_SCAN_EN D=n1667
+ CK=CTS_2 RN=FE_OFN5948_n Q=CMF0[16]
XCMF1_reg[16] SDFFRHQXL $PINS SI=CMF1[17] SE=FE_OFN5515_i_SCAN_EN D=n1703
+ CK=CTS_2 RN=FE_OFN5945_n Q=CMF1[16]
Xflag_reg[2] SDFFRHQXL $PINS SI=flag[0] SE=FE_OFN5512_i_SCAN_EN D=n1999
+ CK=CTS_2 RN=FE_OFN5948_n Q=flag[2]
Xr_cnt_reg[0] SDFFRHQXL $PINS SI=CMF0[19] SE=FE_OFN5512_i_SCAN_EN D=n1948
+ CK=CTS_2 RN=FE_OFN5948_n Q=N425
Xr_cnt_reg[2] SDFFSXL $PINS SI=r_cnt[3] SE=FE_OFN5512_i_SCAN_EN D=n1947
+ CK=CTS_2 SN=FE_OFN5948_n Q=n6706 QN=n3634
Xflag_reg[1] SDFFRHQXL $PINS SI=flag[2] SE=FE_OFN5512_i_SCAN_EN D=n1997
+ CK=CTS_2 RN=FE_OFN5948_n Q=flag[1]
Xflag_reg[0] SDFFRHQXL $PINS SI=caddr_rd[0] SE=FE_OFN5512_i_SCAN_EN D=n1998
+ CK=CTS_2 RN=FE_OFN5948_n Q=flag[0]
Xc_cnt_reg[12] SDFFRHQXL $PINS SI=n6724 SE=FE_OFN5512_i_SCAN_EN D=n6608
+ CK=CTS_4 RN=FE_OFN5948_n Q=c_cnt[12]
Xc_cnt_reg[11] SDFFRHQXL $PINS SI=N14817 SE=FE_OFN5512_i_SCAN_EN D=n6609
+ CK=CTS_4 RN=FE_OFN5948_n Q=c_cnt[11]
Xr_cnt_reg[3] SDFFRHQXL $PINS SI=N425 SE=FE_OFN5512_i_SCAN_EN D=n1946 CK=CTS_2
+ RN=FE_OFN5948_n Q=r_cnt[3]
Xc_cnt_reg[10] SDFFRHQX1 $PINS SI=N14816 SE=FE_OFN5512_i_SCAN_EN D=n6610
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14817
Xc_cnt_reg[8] SDFFRHQX1 $PINS SI=N14814 SE=FE_OFN5512_i_SCAN_EN D=n6612
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14815
Xc_cnt_reg[9] SDFFRHQX1 $PINS SI=N14815 SE=FE_OFN5512_i_SCAN_EN D=n6611
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14816
Xc_cnt_reg[7] SDFFRHQX1 $PINS SI=caddr_wr[9] SE=FE_OFN5512_i_SCAN_EN D=n6613
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14814
Xc_cnt_reg[6] SDFFRHQX1 $PINS SI=N14812 SE=FE_OFN5512_i_SCAN_EN D=n6614
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14813
Xr_cnt_reg[1] SDFFRHQXL $PINS SI=n3634 SE=FE_OFN5512_i_SCAN_EN D=n1945 CK=CTS_2
+ RN=FE_OFN5948_n Q=r_cnt[1]
Xregister_reg[4][1] SDFFRHQXL $PINS SI=FE_OFN5557_register_4__2
+ SE=FE_OFN5509_i_SCAN_EN D=n1864 CK=CTS_5 RN=FE_OFN5943_n Q=N1253
Xregister_reg[7][19] SDFFRHQXL $PINS SI=FE_OFN5578_register_7__14
+ SE=FE_OFN5513_i_SCAN_EN D=n1820 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[7][19]
Xc_cnt_reg[2] SDFFRHQXL $PINS SI=N14811 SE=FE_OFN5512_i_SCAN_EN D=n6651
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14809
Xa_cnt_reg[6] SDFFRHQXL $PINS SI=FE_OFN5594_N8543 SE=FE_OFN5510_i_SCAN_EN
+ D=n1727 CK=CTS_2 RN=FE_OFN5633_FE_DBTN149_i_reset Q=a_cnt[6]
Xa_cnt_reg[0] SDFFRHQXL $PINS SI=busy SE=FE_OFN5510_i_SCAN_EN D=n1761 CK=CTS_2
+ RN=FE_OFN5633_FE_DBTN149_i_reset Q=N8543
Xregister_reg[2][2] SDFFRX4 $PINS SI=FE_OFN5543_register_2__4
+ SE=FE_OFN5510_i_SCAN_EN D=n1927 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=n5215 QN=n5214
Xregister_reg[0][5] SDFFRX4 $PINS SI=n5215 SE=FE_OFN5510_i_SCAN_EN D=n1870
+ CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[0][5] QN=n5761
Xregister_reg[1][12] SDFFRHQX1 $PINS SI=FE_OFN5521_register_1__15
+ SE=FE_OFN5510_i_SCAN_EN D=n1897 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[1][12]
Xregister_reg[1][6] SDFFRHQX2 $PINS SI=FE_OFN6015_register_1__5
+ SE=FE_OFN5510_i_SCAN_EN D=n1891 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[1][6]
Xregister_reg[6][7] SDFFRHQXL $PINS SI=FE_OFN5830_register_6__8
+ SE=FE_OFN5514_i_SCAN_EN D=n1783 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[6][7]
Xregister_reg[3][2] SDFFRHQXL $PINS SI=FE_OFN5590_N608 SE=FE_OFN5509_i_SCAN_EN
+ D=n1829 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=N606
Xregister_reg[0][7] SDFFRHQX4 $PINS SI=register[0][8] SE=FE_OFN5510_i_SCAN_EN
+ D=n1872 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[0][7]
Xregister_reg[2][19] SDFFRHQXL $PINS SI=CMF0[0] SE=FE_OFN5512_i_SCAN_EN D=n1925
+ CK=CTS_2 RN=FE_OFN5948_n Q=register[2][19]
Xregister_reg[8][7] SDFFRHQX1 $PINS SI=FE_OFN5587_register_8__6
+ SE=FE_OFN5514_i_SCAN_EN D=n1785 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[8][7]
Xregister_reg[0][13] SDFFRHQX4 $PINS SI=FE_DBTN1170_register_0_17
+ SE=FE_OFN5512_i_SCAN_EN D=n1878 CK=CTS_1 RN=FE_OFN5634_FE_DBTN149_i_reset
+ Q=register[0][13]
Xregister_reg[5][11] SDFFRHQX4 $PINS SI=FE_OFN5565_register_5__6
+ SE=FE_OFN5509_i_SCAN_EN D=n1916 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][11]
Xregister_reg[3][15] SDFFRHQX4 $PINS SI=FE_OFN5765_register_3__14
+ SE=FE_OFN5509_i_SCAN_EN D=n1855 CK=CTS_1 RN=FE_OFN5632_FE_DBTN149_i_reset
+ Q=register[3][15]
Xregister_reg[6][10] SDFFRHQX4 $PINS SI=FE_OFN5575_register_6__3
+ SE=FE_OFN5514_i_SCAN_EN D=n1792 CK=CTS_5 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[6][10]
Xregister_reg[1][8] SDFFRHQX1 $PINS SI=iaddr[8] SE=FE_OFN5510_i_SCAN_EN D=n1893
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=register[1][8]
Xregister_reg[8][1] SDFFRHQX1 $PINS SI=FE_OFN6005_N999 SE=FE_OFN5514_i_SCAN_EN
+ D=n1767 CK=CTS_5 RN=FE_OFN5637_FE_DBTN149_i_reset Q=n5323
Xregister_reg[4][2] SDFFRHQXL $PINS SI=FE_OFN5827_register_4__5
+ SE=FE_OFN5509_i_SCAN_EN D=n1830 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][2]
Xregister_reg[6][15] SDFFRHQXL $PINS SI=FE_OFN5581_register_7__5
+ SE=FE_OFN5513_i_SCAN_EN D=n1807 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[6][15]
Xregister_reg[1][10] SDFFRHQX2 $PINS SI=FE_OFN6021_register_1__6
+ SE=FE_OFN5510_i_SCAN_EN D=n1895 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[1][10]
Xregister_reg[4][6] SDFFRHQX4 $PINS SI=FE_OFN5602_n4937 SE=FE_OFN5509_i_SCAN_EN
+ D=n1838 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][6]
Xregister_reg[5][12] SDFFRHQXL $PINS SI=FE_OFN5910_register_4__16
+ SE=FE_OFN5509_i_SCAN_EN D=n1917 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][12]
Xregister_reg[5][13] SDFFRHQX4 $PINS SI=FE_OFN5558_register_5__19
+ SE=FE_OFN5509_i_SCAN_EN D=n1918 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][13]
Xc_cnt_reg[4] SDFFRHQX1 $PINS SI=N14810 SE=FE_OFN5512_i_SCAN_EN D=n6616
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14811
Xregister_reg[4][12] SDFFRHQXL $PINS SI=FE_OFN5561_register_5__12
+ SE=FE_OFN5509_i_SCAN_EN D=n1850 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][12]
Xregister_reg[6][19] SDFFRHQX4 $PINS SI=FE_OFN5984_register_6__15
+ SE=FE_OFN5513_i_SCAN_EN D=n1819 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[6][19]
Xregister_reg[6][17] SDFFRHQX4 $PINS SI=FE_OFN5580_register_7__12
+ SE=FE_OFN5513_i_SCAN_EN D=n1813 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[6][17]
Xregister_reg[8][15] SDFFRHQXL $PINS SI=FE_OFN5584_register_8__14
+ SE=FE_OFN5513_i_SCAN_EN D=n1809 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[8][15]
Xregister_reg[4][4] SDFFRHQX4 $PINS SI=register[4][6] SE=FE_OFN5509_i_SCAN_EN
+ D=n1834 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][4]
Xregister_reg[6][13] SDFFRHQXL $PINS SI=register[6][14] SE=FE_OFN5514_i_SCAN_EN
+ D=n1801 CK=CTS_5 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[6][13]
Xregister_reg[8][2] SDFFRHQX4 $PINS SI=FE_OFN5953_n5323 SE=FE_OFN5514_i_SCAN_EN
+ D=n1770 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[8][2]
Xregister_reg[6][12] SDFFRHQX4 $PINS SI=register[7][3] SE=FE_OFN5513_i_SCAN_EN
+ D=n1798 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[6][12]
Xregister_reg[2][14] SDFFRHQXL $PINS SI=FE_DBTN1159_register_2_8
+ SE=FE_OFN5512_i_SCAN_EN D=n1939 CK=CTS_1 RN=FE_OFN5634_FE_DBTN149_i_reset
+ Q=register[2][14]
Xregister_reg[4][7] SDFFRHQX4 $PINS SI=register[4][0] SE=FE_OFN5509_i_SCAN_EN
+ D=n1840 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][7]
Xregister_reg[0][14] SDFFRHQXL $PINS SI=FE_OFN5516_register_0__18
+ SE=FE_OFN5510_i_SCAN_EN D=n1879 CK=CTS_1 RN=FE_DBTN149_i_reset
+ Q=register[0][14]
Xregister_reg[8][17] SDFFRHQX1 $PINS SI=FE_OFN5979_register_8__16
+ SE=FE_OFN5513_i_SCAN_EN D=n1815 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[8][17]
Xregister_reg[0][11] SDFFRHQXL $PINS SI=iaddr[10] SE=FE_OFN5510_i_SCAN_EN
+ D=n1876 CK=CTS_1 RN=FE_DBTN149_i_reset Q=register[0][11]
Xregister_reg[6][14] SDFFRHQX2 $PINS SI=register[6][12] SE=FE_OFN5513_i_SCAN_EN
+ D=n1804 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[6][14]
Xregister_reg[4][10] SDFFRHQXL $PINS SI=FE_OFN5556_register_4__8
+ SE=FE_OFN5509_i_SCAN_EN D=n1846 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][10]
Xregister_reg[4][11] SDFFRHQXL $PINS SI=register[4][7] SE=FE_OFN5509_i_SCAN_EN
+ D=n1848 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][11]
Xregister_reg[8][5] SDFFRHQXL $PINS SI=FE_OFN6018_register_8__4
+ SE=FE_OFN5514_i_SCAN_EN D=n1779 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[8][5]
Xregister_reg[3][17] SDFFRHQX2 $PINS SI=register[3][19] SE=FE_OFN5509_i_SCAN_EN
+ D=n1859 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[3][17]
Xregister_reg[4][15] SDFFRHQX4 $PINS SI=register[5][17] SE=FE_OFN5509_i_SCAN_EN
+ D=n1856 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][15]
Xregister_reg[5][7] SDFFRHQXL $PINS SI=register[5][11] SE=FE_OFN5509_i_SCAN_EN
+ D=n1912 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][7]
Xregister_reg[4][13] SDFFRHQX4 $PINS SI=register[5][5] SE=FE_OFN5509_i_SCAN_EN
+ D=n1852 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][13]
Xregister_reg[3][5] SDFFRHQX2 $PINS SI=n5101 SE=FE_OFN5509_i_SCAN_EN D=n1835
+ CK=CTS_1 RN=FE_OFN5943_n Q=N609
Xregister_reg[1][14] SDFFRHQX2 $PINS SI=FE_OFN5520_register_1__16
+ SE=FE_OFN5510_i_SCAN_EN D=n1899 CK=CTS_1 RN=FE_DBTN149_i_reset
+ Q=register[1][14]
Xregister_reg[8][4] SDFFRHQXL $PINS SI=register[8][3] SE=FE_OFN5514_i_SCAN_EN
+ D=n1776 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[8][4]
Xregister_reg[8][3] SDFFRHQX2 $PINS SI=register[8][2] SE=FE_OFN5514_i_SCAN_EN
+ D=n1773 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[8][3]
Xregister_reg[0][6] SDFFRHQX4 $PINS SI=FE_OFN5621_CMF0_3
+ SE=FE_OFN5510_i_SCAN_EN D=n1871 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[0][6]
Xc_cnt_reg[5] SDFFRHQX1 $PINS SI=N14808 SE=FE_OFN5512_i_SCAN_EN D=n6615
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14812
Xregister_reg[0][9] SDFFRHQX4 $PINS SI=register[0][6] SE=FE_OFN5510_i_SCAN_EN
+ D=n1874 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[0][9]
Xregister_reg[4][0] SDFFRHQX4 $PINS SI=FE_OFN6039_N1177 SE=FE_OFN5509_i_SCAN_EN
+ D=n1826 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][0]
Xregister_reg[5][14] SDFFRHQX4 $PINS SI=register[5][13] SE=FE_OFN5509_i_SCAN_EN
+ D=n1919 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][14]
Xregister_reg[4][9] SDFFRHQXL $PINS SI=FE_OFN5874_register_4__10
+ SE=FE_OFN5509_i_SCAN_EN D=n1844 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][9]
XCMF0_reg[34] SDFFRXL $PINS SI=n5116 SE=FE_OFN5512_i_SCAN_EN D=n5132 CK=CTS_4
+ RN=FE_OFN5948_n Q=n5118 QN=n6724
XCMF0_reg[35] SDFFRXL $PINS SI=n6725 SE=FE_OFN5512_i_SCAN_EN D=n5131 CK=CTS_4
+ RN=FE_OFN5948_n Q=n5117 QN=n5116
Xregister_reg[1][11] SDFFRHQX1 $PINS SI=FE_OFN6003_register_1__10
+ SE=FE_OFN5510_i_SCAN_EN D=n1896 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[1][11]
Xregister_reg[5][18] SDFFRHQX4 $PINS SI=FE_OFN5560_register_5__15
+ SE=FE_OFN5509_i_SCAN_EN D=n1923 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][18]
Xregister_reg[8][6] SDFFRHQXL $PINS SI=FE_DBTN1163_register_8_5
+ SE=FE_OFN5514_i_SCAN_EN D=n1782 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[8][6]
Xregister_reg[8][0] SDFFRHQXL $PINS SI=FE_OFN5848_FE_DBTN21_N1711
+ SE=FE_OFN5514_i_SCAN_EN D=n1764 CK=CTS_5 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=N999
Xregister_reg[5][8] SDFFRHQX4 $PINS SI=FE_OFN5564_register_5__7
+ SE=FE_OFN5509_i_SCAN_EN D=n1913 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][8]
Xregister_reg[3][19] SDFFRHQX2 $PINS SI=FE_OFN5546_register_3__16
+ SE=FE_OFN5509_i_SCAN_EN D=n1827 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[3][19]
Xregister_reg[8][13] SDFFRHQXL $PINS SI=FE_OFN5585_register_8__12
+ SE=FE_OFN5513_i_SCAN_EN D=n1803 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[8][13]
Xregister_reg[0][2] SDFFRX4 $PINS SI=n5761 SE=FE_OFN5510_i_SCAN_EN D=n1867
+ CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=n5113 QN=n5114
XCMF0_reg[33] SDFFRXL $PINS SI=n6726 SE=FE_OFN5512_i_SCAN_EN D=n5119 CK=CTS_4
+ RN=FE_OFN5948_n Q=n5112 QN=n6725
XCMF0_reg[32] SDFFRXL $PINS SI=CMF0[31] SE=FE_OFN5512_i_SCAN_EN D=n5140
+ CK=CTS_4 RN=FE_OFN5948_n Q=n5111 QN=n6726
Xregister_reg[1][17] SDFFRHQXL $PINS SI=FE_DBTN139_register_0_7
+ SE=FE_OFN5510_i_SCAN_EN D=n1902 CK=CTS_1 RN=FE_DBTN149_i_reset
+ Q=register[1][17]
Xregister_reg[0][19] SDFFRHQX4 $PINS SI=n5105 SE=FE_OFN5510_i_SCAN_EN D=n1884
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=register[0][19]
Xregister_reg[8][16] SDFFRHQXL $PINS SI=FE_OFN5582_register_8__19
+ SE=FE_OFN5513_i_SCAN_EN D=n1812 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[8][16]
Xregister_reg[6][16] SDFFRHQX2 $PINS SI=register[6][17] SE=FE_OFN5515_i_SCAN_EN
+ D=n1810 CK=CTS_2 RN=FE_OFN5945_n Q=register[6][16]
Xregister_reg[3][13] SDFFRX1 $PINS SI=FE_OFN5591_N610 SE=FE_OFN5509_i_SCAN_EN
+ D=n1851 CK=CTS_1 RN=FE_OFN5943_n Q=n6723 QN=n5107
Xregister_reg[1][18] SDFFRX4 $PINS SI=FE_OFN5997_register_1__12
+ SE=FE_OFN5510_i_SCAN_EN D=n1903 CK=CTS_1 RN=FE_DBTN149_i_reset Q=n5105 QN=n5104
Xregister_reg[3][9] SDFFRX1 $PINS SI=FE_OFN5548_register_3__11
+ SE=FE_OFN5509_i_SCAN_EN D=n1843 CK=CTS_1 RN=FE_OFN5943_n Q=n5102 QN=n5101
Xregister_reg[3][18] SDFFRHQXL $PINS SI=a_cnt[12] SE=FE_OFN5509_i_SCAN_EN
+ D=n1861 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[3][18]
Xregister_reg[0][12] SDFFRHQXL $PINS SI=FE_OFN6002_register_1__11
+ SE=FE_OFN5510_i_SCAN_EN D=n1877 CK=CTS_1 RN=FE_DBTN149_i_reset
+ Q=register[0][12]
Xc_cnt_reg[0] SDFFRHQXL $PINS SI=c_cnt[12] SE=FE_OFN5512_i_SCAN_EN D=n6649
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14807
Xregister_reg[3][16] SDFFRHQXL $PINS SI=FE_OFN5545_register_3__18
+ SE=FE_OFN5509_i_SCAN_EN D=n1857 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[3][16]
Xregister_reg[7][17] SDFFRHQX1 $PINS SI=register[7][18] SE=FE_OFN5515_i_SCAN_EN
+ D=n1814 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[7][17]
Xregister_reg[7][18] SDFFRHQXL $PINS SI=FE_OFN5583_register_8__18
+ SE=FE_OFN5515_i_SCAN_EN D=n1817 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[7][18]
Xregister_reg[3][3] SDFFRHQXL $PINS SI=register[3][15] SE=FE_OFN5509_i_SCAN_EN
+ D=n1831 CK=CTS_1 RN=FE_OFN5632_FE_DBTN149_i_reset Q=N607
Xregister_reg[1][9] SDFFRHQX1 $PINS SI=register[0][9] SE=FE_OFN5510_i_SCAN_EN
+ D=n1894 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[1][9]
Xregister_reg[1][7] SDFFRHQX2 $PINS SI=FE_OFN5525_register_1__8
+ SE=FE_OFN5510_i_SCAN_EN D=n1892 CK=CTS_1 RN=FE_DBTN149_i_reset Q=register[1][7]
Xregister_reg[2][9] SDFFRHQXL $PINS SI=register[0][13] SE=FE_OFN5510_i_SCAN_EN
+ D=n1934 CK=CTS_1 RN=FE_DBTN149_i_reset Q=register[2][9]
Xregister_reg[1][15] SDFFRHQX1 $PINS SI=FE_OFN5901_register_0__12
+ SE=FE_OFN5510_i_SCAN_EN D=n1900 CK=CTS_1 RN=FE_DBTN149_i_reset
+ Q=register[1][15]
Xregister_reg[1][13] SDFFRHQXL $PINS SI=FE_OFN5522_register_1__14
+ SE=FE_OFN5510_i_SCAN_EN D=n1898 CK=CTS_1 RN=FE_DBTN149_i_reset
+ Q=register[1][13]
Xregister_reg[2][16] SDFFRHQXL $PINS SI=CMF0[4] SE=FE_OFN5512_i_SCAN_EN D=n1941
+ CK=CTS_2 RN=FE_OFN5948_n Q=register[2][16]
Xregister_reg[3][4] SDFFRHQXL $PINS SI=FE_OFN6017_register_3__17
+ SE=FE_OFN5509_i_SCAN_EN D=n1833 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=N608
Xregister_reg[6][4] SDFFRHQXL $PINS SI=FE_OFN5572_register_6__6
+ SE=FE_OFN5514_i_SCAN_EN D=n1774 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[6][4]
Xregister_reg[6][3] SDFFRHQXL $PINS SI=CMF1[3] SE=FE_OFN5514_i_SCAN_EN D=n1771
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[6][3]
Xregister_reg[6][9] SDFFRHQXL $PINS SI=CMF1[5] SE=FE_OFN5514_i_SCAN_EN D=n1789
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[6][9]
Xregister_reg[3][14] SDFFRHQXL $PINS SI=FE_OFN5588_N606 SE=FE_OFN5509_i_SCAN_EN
+ D=n1853 CK=CTS_1 RN=FE_OFN5633_FE_DBTN149_i_reset Q=register[3][14]
Xc_cnt_reg[1] SDFFRHQX1 $PINS SI=N14809 SE=FE_OFN5512_i_SCAN_EN D=n6650
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14808
Xc_cnt_reg[3] SDFFRHQX1 $PINS SI=N14807 SE=FE_OFN5512_i_SCAN_EN D=n6617
+ CK=CTS_4 RN=FE_OFN5948_n Q=N14810
Xregister_reg[7][12] SDFFRHQXL $PINS SI=register[7][15] SE=FE_OFN5515_i_SCAN_EN
+ D=n1799 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset Q=register[7][12]
Xregister_reg[7][14] SDFFRHQXL $PINS SI=FE_DBTN76_register_6_18
+ SE=FE_OFN5513_i_SCAN_EN D=n1805 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[7][14]
Xregister_reg[6][6] SDFFRHQXL $PINS SI=FE_OFN5571_register_6__7
+ SE=FE_OFN5514_i_SCAN_EN D=n1780 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[6][6]
Xregister_reg[6][1] SDFFRHQXL $PINS SI=n5321 SE=FE_OFN5514_i_SCAN_EN D=n1765
+ CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=N872
Xregister_reg[4][3] SDFFRX1 $PINS SI=FE_OFN5865_register_4__11
+ SE=FE_OFN5509_i_SCAN_EN D=n1832 CK=CTS_5 RN=FE_OFN5943_n Q=n4938 QN=n4937
Xregister_reg[4][18] SDFFRHQXL $PINS SI=FE_OFN5552_register_4__14
+ SE=FE_OFN5509_i_SCAN_EN D=n1862 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][18]
Xregister_reg[4][19] SDFFRHQXL $PINS SI=register[5][8] SE=FE_OFN5509_i_SCAN_EN
+ D=n1828 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][19]
Xregister_reg[2][7] SDFFRHQXL $PINS SI=FE_OFN5519_register_1__19
+ SE=FE_OFN5510_i_SCAN_EN D=n1932 CK=CTS_1 RN=FE_OFN5634_FE_DBTN149_i_reset
+ Q=register[2][7]
Xregister_reg[2][11] SDFFRHQXL $PINS SI=FE_DBTN1156_register_2_14
+ SE=FE_OFN5512_i_SCAN_EN D=n1936 CK=CTS_1 RN=FE_OFN5948_n Q=register[2][11]
Xregister_reg[2][8] SDFFRHQXL $PINS SI=n6772 SE=FE_OFN5512_i_SCAN_EN D=n1933
+ CK=CTS_1 RN=FE_OFN5634_FE_DBTN149_i_reset Q=register[2][8]
Xregister_reg[3][11] SDFFRHQXL $PINS SI=FE_OFN5592_N611 SE=FE_OFN5509_i_SCAN_EN
+ D=n1847 CK=CTS_1 RN=FE_OFN5943_n Q=register[3][11]
Xregister_reg[2][17] SDFFRHQXL $PINS SI=CMF0[6] SE=FE_OFN5510_i_SCAN_EN D=n1942
+ CK=CTS_1 RN=FE_DBTN149_i_reset Q=register[2][17]
Xregister_reg[2][15] SDFFRHQXL $PINS SI=FE_OFN5544_register_2__1
+ SE=FE_OFN5512_i_SCAN_EN D=n1940 CK=CTS_1 RN=FE_OFN5948_n Q=register[2][15]
Xregister_reg[5][5] SDFFRHQX4 $PINS SI=N1316 SE=FE_OFN5509_i_SCAN_EN D=n1910
+ CK=CTS_5 RN=FE_OFN5943_n Q=register[5][5]
Xregister_reg[6][5] SDFFRHQXL $PINS SI=FE_DBTN62_register_6_4
+ SE=FE_OFN5514_i_SCAN_EN D=n1777 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[6][5]
Xregister_reg[5][9] SDFFRHQXL $PINS SI=FE_OFN5562_register_5__10
+ SE=FE_OFN5509_i_SCAN_EN D=n1914 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][9]
Xregister_reg[2][18] SDFFRHQXL $PINS SI=CMF0[17] SE=FE_OFN5512_i_SCAN_EN
+ D=n1943 CK=CTS_2 RN=FE_OFN5948_n Q=register[2][18]
Xregister_reg[5][10] SDFFRHQXL $PINS SI=FE_OFN5740_register_4__19
+ SE=FE_OFN5509_i_SCAN_EN D=n1915 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][10]
Xregister_reg[8][12] SDFFRHQXL $PINS SI=FE_OFN297_register_8__9
+ SE=FE_OFN5513_i_SCAN_EN D=n1800 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[8][12]
Xregister_reg[4][14] SDFFRHQXL $PINS SI=register[4][13] SE=FE_OFN5509_i_SCAN_EN
+ D=n1854 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][14]
Xregister_reg[5][15] SDFFRHQXL $PINS SI=register[5][14] SE=FE_OFN5509_i_SCAN_EN
+ D=n1920 CK=CTS_5 RN=FE_OFN5943_n Q=register[5][15]
Xregister_reg[4][16] SDFFRHQXL $PINS SI=FE_OFN5563_register_5__9
+ SE=FE_OFN5509_i_SCAN_EN D=n1858 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][16]
Xregister_reg[3][6] SDFFRHQXL $PINS SI=FE_OFN5593_N612 SE=FE_OFN5509_i_SCAN_EN
+ D=n1837 CK=CTS_1 RN=FE_OFN5943_n Q=N610
Xregister_reg[3][7] SDFFRHQXL $PINS SI=iaddr[4] SE=FE_OFN5509_i_SCAN_EN D=n1839
+ CK=CTS_1 RN=FE_OFN5943_n Q=N611
Xregister_reg[3][8] SDFFRHQXL $PINS SI=FE_OFN5549_register_3__10
+ SE=FE_OFN5509_i_SCAN_EN D=n1841 CK=CTS_1 RN=FE_OFN5943_n Q=N612
Xregister_reg[6][8] SDFFRHQXL $PINS SI=FE_OFN5568_register_6__11
+ SE=FE_OFN5514_i_SCAN_EN D=n1786 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[6][8]
Xregister_reg[7][13] SDFFRHQXL $PINS SI=FE_OFN5576_register_7__19
+ SE=FE_OFN5513_i_SCAN_EN D=n1802 CK=CTS_2 RN=FE_OFN5637_FE_DBTN149_i_reset
+ Q=register[7][13]
Xregister_reg[4][8] SDFFRHQXL $PINS SI=FE_OFN5601_N1253 SE=FE_OFN5509_i_SCAN_EN
+ D=n1842 CK=CTS_5 RN=FE_OFN5943_n Q=register[4][8]
Xregister_reg[6][11] SDFFRHQXL $PINS SI=FE_OFN5569_register_6__9
+ SE=FE_OFN5514_i_SCAN_EN D=n1795 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset
+ Q=register[6][11]
XU3098 AOI22X1 $PINS A0=FE_RN_17 A1=n6675 B0=n4932 B1=n6676 Y=n4586
XU3099 INVX1 $PINS A=n5260 Y=n5674
XU3101 CLKINVX3 $PINS A=n100 Y=n5153
XU3108 AOI222X1 $PINS A0=n213 A1=FE_OFN6130_n5000 B0=FE_OFN6049_register_0__14
+ B1=FE_OFN6125_n5007 C0=FE_OFN5522_register_1__14 C1=FE_OCPN6195_n5002 Y=n5724
XU3109 AOI222X1 $PINS A0=n215 A1=FE_OFN6130_n5000 B0=FE_OFN5901_register_0__12
+ B1=FE_OFN6125_n5007 C0=FE_OFN5997_register_1__12 C1=FE_OCPN6195_n5002 Y=n5728
XU3113 NAND2X2 $PINS A=N1696 B=n5807 Y=n5261
XU3114 XOR2X2 $PINS A=n5807 B=N1696 Y=N1732
XU3115 INVX1 $PINS A=n5805 Y=n5816
XU3117 OAI2BB1X2 $PINS A0N=FE_DBTN30_N609 A1N=n4826 B0=register[3][15] Y=n4827
XU3118 INVX1 $PINS A=n5525 Y=n4826
XU3119 OAI2BB1X2 $PINS A0N=FE_OFN5588_N606 A1N=n5529 B0=n4838 Y=n5405
XU3120 NAND2BX1 $PINS AN=n5519 B=n4807 Y=n5514
XU3121 NAND3X2 $PINS A=n4922 B=n4923 C=n4924 Y=n4912
XU3123 XOR2X2 $PINS A=n5654 B=register[7][15] Y=FE_OFN549_n4975
XU3124 NAND3X2 $PINS A=n5799 B=n5798 C=n5797 Y=N1740
XU3126 NAND2X1 $PINS A=n5818 B=FE_DBTN25_N1699 Y=n4892
XU3128 NAND2X4 $PINS A=n4892 B=n4893 Y=N1735
XU3135 NAND3X4 $PINS A=N1699 B=n5786 C=n5785 Y=n4941
XU3137 AOI222X2 $PINS A0=FE_OCPN6213_register_7__2 A1=FE_OCPN6200_n5237
+ B0=FE_OFN5653_n4656 B1=FE_OFN5630_CMF1_2 C0=n4963 C1=FE_OCPN6203_n5238 Y=n5906
XU3140 AOI222X1 $PINS A0=FE_OFN5897_register_7__7 A1=FE_OCPN6200_n5237
+ B0=CMF1[7] B1=FE_OFN5653_n4656 C0=FE_OCPN6203_n5238 C1=FE_OFN5571_register_6__7
+ Y=n5896
XU3147 XOR2X2 $PINS A=N1709 B=n5788 Y=N1745
XU3152 OR2X2 $PINS A=register[7][3] B=n5670 Y=n5669
XU3154 NAND2X1 $PINS A=n5174 B=n5175 Y=N625
XU3155 OAI211X1 $PINS A0=FE_OFN608_n5011 A1=n5148 B0=n4949 C0=n4950 Y=n5145
XU3156 CLKINVX3 $PINS A=n101 Y=n5148
XU3158 NAND3XL $PINS A=n5808 B=N1699 C=n5818 Y=n5809
XU3162 XOR2X1 $PINS A=n5552 B=register[5][17] Y=r2236/DIFF[17]
XU3163 XOR2X2 $PINS A=n5777 B=register[0][8] Y=n4885
XU3165 OR2X2 $PINS A=FE_DBTN32_N607 B=FE_OFN5934_n5107 Y=n4830
XU3166 OR4X2 $PINS A=FE_OFN5579_register_7__13 B=register[7][11]
+ C=FE_OFN5578_register_7__14 D=FE_OFN5580_register_7__12 Y=n5653
XU3168 AND2X2 $PINS A=n5283 B=FE_OFN5546_register_3__16 Y=n5511
XU3170 OAI2BB1X2 $PINS A0N=n5262 A1N=n5807 B0=n5806 Y=n5818
XU3171 OAI2BB1X2 $PINS A0N=N1705 A1N=n5797 B0=n5795 Y=N1741
XU3172 OR2X2 $PINS A=N1708 B=n5790 Y=n5789
XU3174 NAND4X1 $PINS A=N14817 B=N14816 C=c_cnt[11] D=n4797 Y=n4794
XU3180 INVX1 $PINS A=n4389 Y=n6705
XU3184 INVX1 $PINS A=FE_OFN6002_register_1__11 Y=n5212
XU3211 OAI222XL $PINS A0=FE_OFN5956_n5349 A1=n5107 B0=n5225
+ B1=FE_OFN309_register_4__13 C0=FE_OFN6126_n5229 C1=n5089 Y=n1851
XU3212 OAI222XL $PINS A0=n5099 A1=n5509 B0=FE_OFN5928_n5502 B1=n5507 C0=n5114
+ C1=n5435 Y=n1867
XU3213 OAI222XL $PINS A0=n5225 A1=FE_OFN5550_register_4__19 B0=FE_OFN5956_n5349
+ B1=FE_DBTN1162_register_3_19 C0=FE_OFN6126_n5229 C1=n5071 Y=n1827
XU3214 OAI222XL $PINS A0=n5225 A1=FE_OFN5826_register_4__5 B0=FE_OFN5956_n5349
+ B1=FE_DBTN30_N609 C0=FE_OFN6126_n5229 C1=n5063 Y=n1835
XU3215 OAI222XL $PINS A0=FE_OFN5956_n5349 A1=FE_OFN5707_register_3__17 B0=n5225
+ B1=FE_DBTN0_n6728 C0=FE_OFN6126_n5229 C1=n5067 Y=n1859
XU3216 OAI222XL $PINS A0=FE_OFN5956_n5349 A1=FE_OFN5878_register_3__15 B0=n5225
+ B1=FE_OFN5711_register_4__15 C0=FE_OFN6126_n5229 C1=n5093 Y=n1855
XU3217 OAI222XL $PINS A0=n5225 A1=FE_DBTN14_N1254 B0=FE_OFN5956_n5349
+ B1=FE_OFN349_N606 C0=FE_OFN6126_n5229 C1=n5099 Y=n1829
XU3219 AOI222X1 $PINS A0=CMF1[20] A1=FE_OFN5857_n4910 B0=n5011 B1=n112 C0=n5272
+ C1=n72 Y=n5832
XU3220 AOI222X1 $PINS A0=CMF1[24] A1=FE_OFN5857_n4910 B0=n5011 B1=n108 C0=n68
+ C1=n5272 Y=n5828
XU3221 AOI222X1 $PINS A0=CMF1[22] A1=FE_OFN5857_n4910 B0=n5011 B1=n110 C0=n70
+ C1=n5272 Y=n5830
XU3222 AOI222X1 $PINS A0=CMF1[21] A1=FE_OFN5857_n4910 B0=n5011 B1=n111 C0=n71
+ C1=n5272 Y=n5831
XU3223 AOI222X1 $PINS A0=CMF1[23] A1=FE_OFN5857_n4910 B0=n5011 B1=n109 C0=n69
+ C1=n5272 Y=n5829
XU3224 INVX1 $PINS A=n5685 Y=n2281
XU3225 AOI222X1 $PINS A0=CMF0[24] A1=FE_OFN6094_n4911 B0=n203 B1=n5009 C0=n88
+ C1=n5275 Y=n5685
XU3226 INVX1 $PINS A=n5686 Y=n4870
XU3227 AOI222X4 $PINS A0=n120 A1=FE_OFN5978_n5340 B0=n5341
+ B1=FE_OFN5824_register_4__12 C0=n5342 C1=FE_OFN5561_register_5__12 Y=n5887
XU3228 AOI222X4 $PINS A0=n119 A1=FE_OFN5978_n5340 B0=n5341
+ B1=FE_OFN5748_register_4__13 C0=n5342 C1=register[5][13] Y=n5885
XU3229 INVX1 $PINS A=CMF0[30] Y=n5122
XU3230 INVX1 $PINS A=n82 Y=n5124
XU3231 CLKINVX3 $PINS A=n197 Y=n5123
XU3232 NAND3X1 $PINS A=n5171 B=n5172 C=n5173 Y=n5016
XU3233 NAND2X1 $PINS A=n198 B=n5009 Y=n5172
XU3234 OAI222XL $PINS A0=n5225 A1=FE_OFN6068_register_4__12 B0=FE_OFN5956_n5349
+ B1=FE_DBTN1171_register_3_12 C0=FE_OFN6126_n5229 C1=n5087 Y=n1849
XU3236 OAI222XL $PINS A0=n5225 A1=FE_DBTN12_N1252 B0=FE_OFN5956_n5349
+ B1=FE_DBTN10_N1176 C0=FE_OFN6126_n5229 C1=n5073 Y=n1825
XU3237 OAI222XL $PINS A0=FE_OFN5956_n5349 A1=FE_DBTN105_register_3_10 B0=n5225
+ B1=FE_OFN5554_register_4__10 C0=FE_OFN6126_n5229 C1=n5065 Y=n1845
XU3238 OAI221X4 $PINS A0=n5049 A1=FE_OFN5970_n5481 B0=FE_OFN5534_register_2__14
+ B1=n5330 C0=n5447 Y=n1899
XU3239 OAI221XL $PINS A0=n5041 A1=FE_OFN5970_n5481 B0=FE_OFN5781_register_2__10
+ B1=n5330 C0=n5458 Y=n1895
XU3241 OAI221XL $PINS A0=FE_DBTN45_register_8_13 A1=n5335 B0=n5047
+ B1=FE_OFN6013_n5336 C0=n5593 Y=n1802
XU3242 OAI221X4 $PINS A0=FE_OFN200_i_idata_8 A1=FE_OFN5970_n5481
+ B0=FE_OFN5755_register_2__8 B1=n5330 C0=n5464 Y=n1893
XU3243 OAI221X1 $PINS A0=n5033 A1=FE_OFN5970_n5481 B0=FE_OFN5788_register_2__6
+ B1=n5330 C0=n5470 Y=n1891
XU3244 OAI221XL $PINS A0=n5045 A1=FE_OFN5970_n5481 B0=FE_DBTN122_register_2_12
+ B1=n5330 C0=n5453 Y=n1897
XU3245 NOR2X1 $PINS A=n6701 B=n6712 Y=n4444
XU3246 OAI221XL $PINS A0=FE_DBTN1176_register_8_19 A1=n5335 B0=n5059
+ B1=FE_OFN6013_n5336 C0=n5569 Y=n1820
XU3247 NAND2X2 $PINS A=n5350 B=n4441 Y=n5481
XU3248 NAND2X1 $PINS A=n5348 B=FE_OFN5796_n4440 Y=n5636
XU3249 MX2X1 $PINS S0=FE_OFN5685_FE_RN_5 B=N8545 A=caddr_rd[1] Y=n6666
XU3250 NAND2X2 $PINS A=FE_OCPN6250_n5505 B=FE_OFN5796_n4440 Y=n5334
XU3251 OAI221XL $PINS A0=FE_OFN228_i_idata_2 A1=FE_OFN5970_n5481 B0=n5214
+ B1=n5330 C0=n5478 Y=n1887
XU3252 OAI221XL $PINS A0=n5023 A1=n5329 B0=FE_DBTN1181_register_2_1 B1=n5330
+ C0=n5480 Y=n1886
XU3253 NOR2X2 $PINS A=FE_DBTN1154_n4656 B=n5835 Y=n5340
XU3254 OAI221X4 $PINS A0=n5029 A1=FE_OFN5970_n5481 B0=FE_DBTN1155_register_2_4
+ B1=n5330 C0=n5474 Y=n1889
XU3256 OR3XL $PINS A=N14810 B=N14812 C=N14811 Y=n5285
XU3259 NAND2X4 $PINS A=FE_OFN5649_n4407 B=n4408 Y=n5352
XU3261 AOI21XL $PINS A0=n6712 A1=n4367 B0=FE_OFN5651_n4638 Y=n4787
XU3262 INVX1 $PINS A=n4390 Y=n6712
XU3265 NAND2X4 $PINS A=FE_RN_7 B=n4628 Y=n4560
XU3267 MX2X1 $PINS S0=FE_OFN5641_FE_RN_194_0 B=FE_OFN5609_a_cnt_6 A=iaddr[6]
+ Y=n3686
XU3268 OAI221XL $PINS A0=FE_DBTN1169_register_8_3 A1=n5335 B0=n5027
+ B1=FE_OFN6013_n5336 C0=n5627 Y=n1772
XU3269 XOR2X4 $PINS A=n5248 B=FE_OFN5580_register_7__12 Y=FE_OFN5405_n4983
XU3271 INVXL $PINS A=n4410 Y=n6641
XU3272 NAND2XL $PINS A=n6644 B=n4755 Y=n4360
XU3274 OAI211X1 $PINS A0=FE_OFN5835_N1281 A1=n5426 B0=n5390 C0=n5389 Y=n1826
XU3276 MX2X1 $PINS S0=FE_OFN5641_FE_RN_194_0 B=FE_OFN5599_N8549 A=iaddr[5]
+ Y=n3687
XU3277 OAI221XL $PINS A0=FE_DBTN34_register_8_2 A1=FE_OCPN6261_n5636
+ B0=FE_OFN228_i_idata_2 B1=FE_OFN6013_n5336 C0=n5630 Y=n1769
XU3278 XNOR2X2 $PINS A=n5245 B=n5649 Y=n4905
XU3284 NAND2X1 $PINS A=FE_RN_7 B=n4526 Y=n4546
XU3285 OAI211X1 $PINS A0=FE_DBTN78_register_5_3 A1=n5426 B0=n5402 C0=n5401
+ Y=n1832
XU3286 OAI221XL $PINS A0=n5021 A1=FE_OFN5970_n5481 B0=FE_OFN5883_N567 B1=n5330
+ C0=n5484 Y=n1885
XU3287 XNOR2X4 $PINS A=n5657 B=FE_OFN5578_register_7__14 Y=n4906
XU3289 OAI2BB1X2 $PINS A0N=n4375 A1N=n6700 B0=FE_RN_7 Y=n4640
XU3290 AND3X4 $PINS A=n5834 B=n5844 C=n5842 Y=n5272
XU3291 OAI211X1 $PINS A0=FE_OFN400_register_5__7 A1=n5426 B0=n5424 C0=n5423
+ Y=n1840
XU3292 OAI221X4 $PINS A0=n5053 A1=n5329 B0=FE_DBTN126_register_2_16 B1=n5330
+ C0=n5445 Y=n1901
XU3293 XNOR2X1 $PINS A=n5665 B=register[7][8] Y=n4907
XU3295 OAI22X1 $PINS A0=n5287 A1=n4395 B0=n4523 B1=FE_OFN5651_n4638 Y=n4527
XU3296 NOR2XL $PINS A=n6718 B=n4367 Y=n4362
XU3297 NAND3X1 $PINS A=n5169 B=n5168 C=n5170 Y=n5140
XU3298 OAI211X1 $PINS A0=FE_OFN5932_register_5__8 A1=n5426 B0=n5428 C0=n5427
+ Y=n1842
XU3300 AOI22X1 $PINS A0=CMF1[26] A1=FE_OFN5958_n5004 B0=FE_OFN5663_n4999
+ B1=cdata_wr[10] Y=n4280
XU3301 MX2X1 $PINS S0=FE_OFN5641_FE_RN_194_0 B=FE_OFN5598_N8548 A=iaddr[4]
+ Y=n3688
XU3304 XOR2X1 $PINS A=n5666 B=FE_OFN5896_register_7__7 Y=FE_OFN409_n4971
XU3305 NAND3X1 $PINS A=n4374 B=n4794 C=n4443 Y=n4395
XU3306 NAND2BXL $PINS AN=n5534 B=n5233 Y=n5409
XU3307 AOI22X1 $PINS A0=CMF1[27] A1=FE_OFN5958_n5004 B0=FE_OFN5663_n4999
+ B1=cdata_wr[11] Y=n4278
XU3308 OAI221X4 $PINS A0=n5027 A1=n5329 B0=n5475 B1=n5330 C0=n5476 Y=n1888
XU3310 XNOR2X4 $PINS A=n5761 B=n5246 Y=r2257/DIFF[5]
XU3312 OAI2BB1X4 $PINS A0N=n5008 A1N=n5534 B0=n5221 Y=r2236/DIFF[4]
XU3315 AOI22X1 $PINS A0=CMF1[28] A1=FE_OFN5958_n5004 B0=FE_OFN5663_n4999
+ B1=cdata_wr[12] Y=n4276
XU3316 OAI221X4 $PINS A0=n5031 A1=n5329 B0=FE_DBTN116_register_2_5 B1=n5330
+ C0=n5472 Y=n1890
XU3318 XNOR2X2 $PINS A=n5650 B=FE_OFN5576_register_7__19 Y=n4908
XU3320 AOI221X1 $PINS A0=n6703 A1=n4398 B0=n4387 B1=n4399 C0=n4400 Y=n4397
XU3321 INVXL $PINS A=n4650 Y=n6703
XU3322 OAI211X1 $PINS A0=n5537 A1=n5426 B0=n5398 C0=n5397 Y=n1830
XU3323 AOI22X1 $PINS A0=CMF1[29] A1=FE_OFN5958_n5004 B0=FE_OFN5663_n4999
+ B1=cdata_wr[13] Y=n4274
XU3324 MX2X1 $PINS S0=FE_OFN5641_FE_RN_194_0 B=FE_OFN5597_N8547 A=iaddr[3]
+ Y=n3689
XU3326 OAI2BB1X1 $PINS A0N=n5247 A1N=FE_DBTN81_register_5_10 B0=n4917 Y=n2468
XU3329 NAND4BBX2 $PINS AN=n5653 BN=n5660 C=FE_OFN5577_register_7__16 D=n5648
+ Y=n5652
XU3330 NOR2X4 $PINS A=n4556 B=n6775 Y=n4536
XU3332 AOI22X1 $PINS A0=CMF1[30] A1=FE_OFN5958_n5004 B0=FE_OFN5663_n4999
+ B1=cdata_wr[14] Y=n4272
XU3333 MX2X1 $PINS S0=FE_OFN5641_FE_RN_194_0 B=FE_OFN5596_N8546 A=iaddr[2]
+ Y=n3690
XU3335 XOR2X1 $PINS A=n5109 B=FE_OFN6019_register_0__11 Y=n5251
XU3336 NOR2X1 $PINS A=FE_OFN5707_register_3__17 B=FE_OFN89_N611 Y=n5249
XU3337 NAND2X1 $PINS A=n5512 B=n5271 Y=n5277
XU3338 INVX1 $PINS A=n5514 Y=n5512
XU3342 AOI22X1 $PINS A0=CMF1[31] A1=FE_OFN5958_n5004 B0=FE_OFN5663_n4999
+ B1=cdata_wr[15] Y=n4270
XU3343 MX2X1 $PINS S0=FE_OFN5641_FE_RN_194_0 B=FE_OFN5608_a_cnt_7 A=iaddr[7]
+ Y=n3692
XU3345 OAI31X4 $PINS A0=n5793 A1=n5792 A2=n5791 B0=n5790 Y=n6662
XU3348 AOI21X1 $PINS A0=FE_OCPN5439_FE_OFN244_n4560 A1=n4555
+ B0=FE_OFN5760_FE_RN_74_0 Y=n4549
XU3349 AOI22X1 $PINS A0=CMF1[32] A1=FE_OFN5958_n5004 B0=FE_OFN5663_n4999
+ B1=cdata_wr[16] Y=n4268
XU3350 MX2X1 $PINS S0=FE_OFN5687_FE_RN_5 B=FE_OFN5608_a_cnt_7 A=caddr_rd[7]
+ Y=n3680
XU3351 MX2X1 $PINS S0=FE_OFN5641_FE_RN_194_0 B=FE_OFN5607_a_cnt_8 A=iaddr[8]
+ Y=n3693
XU3354 AND2X4 $PINS A=n5540 B=FE_OFN329_register_5__9 Y=n5236
XU3356 NAND2X1 $PINS A=n6655 B=n4830 Y=n4920
XU3357 XOR2X4 $PINS A=n5563 B=FE_OFN5743_register_5__3 Y=r2236/DIFF[3]
XU3358 XNOR3X2 $PINS A=n5101 B=FE_OFN6008_register_3__19 C=n5914 Y=N623
XU3359 OR2X2 $PINS A=FE_OFN5548_register_3__11 B=n5278 Y=n5175
XU3360 AND2X2 $PINS A=n5812 B=n5808 Y=n5800
XU3363 NOR3XL $PINS A=n6711 B=n6701 C=r_cnt[1] Y=n4479
XU3364 NOR2X1 $PINS A=n6633 B=n4374 Y=n4534
XU3366 AOI22X1 $PINS A0=CMF1[33] A1=FE_OFN5958_n5004 B0=FE_OFN5663_n4999
+ B1=cdata_wr[17] Y=n4266
XU3367 AND2X2 $PINS A=CMF1[30] B=FE_OFN5857_n4910 Y=n5180
XU3368 OAI221XL $PINS A0=n5059 A1=FE_OFN5970_n5481 B0=FE_DBTN1175_register_2_19
+ B1=n5330 C0=n5437 Y=n1904
XU3369 XOR2X2 $PINS A=n5557 B=register[5][11] Y=r2236/DIFF[11]
XU3370 NAND2XL $PINS A=FE_DBTN32_N607 B=FE_OFN5934_n5107 Y=n4919
XU3373 OAI2BB1X4 $PINS A0N=n5781 A1N=FE_DBTN137_register_0_3 B0=n5211
+ Y=r2257/DIFF[3]
XU3374 NAND3X2 $PINS A=n5264 B=n5794 C=n5810 Y=n5797
XU3375 NAND2X1 $PINS A=N14471 B=n5260 Y=n5755
XU3378 OAI211X1 $PINS A0=N1282 A1=n5426 B0=n5386 C0=n5385 Y=n1864
XU3379 OAI222XL $PINS A0=n6618 A1=n4377 B0=n6719 B1=FE_OFN599_n4378 C0=n4376
+ C1=n4356 Y=n1945
XU3380 AOI22X1 $PINS A0=CMF1[34] A1=FE_OFN5958_n5004 B0=FE_OFN5663_n4999
+ B1=cdata_wr[18] Y=n4264
XU3381 MX2X1 $PINS S0=FE_OFN5641_FE_RN_194_0 B=FE_OFN5606_a_cnt_9 A=iaddr[9]
+ Y=n3694
XU3382 MX2X1 $PINS S0=FE_OFN5687_FE_RN_5 B=FE_OFN5605_a_cnt_10 A=caddr_rd[10]
+ Y=n3683
XU3383 AND2X2 $PINS A=n5185 B=n5183 Y=n4918
XU3385 NOR4BX1 $PINS AN=n5765 B=register[0][8] C=register[0][9]
+ D=register[0][7] Y=n5279
XU3386 AOI211X2 $PINS A0=n5517 A1=FE_OFN5934_n5107 B0=n5013 C0=n5515 Y=N627
XU3387 CLKINVX3 $PINS A=n4807 Y=n5517
XU3388 NAND2X4 $PINS A=N1701 B=N1702 Y=n5802
XU3391 AOI221X1 $PINS A0=n6701 A1=FE_OFN5603_n5235 B0=n6695 B1=n4340 C0=n4489
+ Y=n4488
XU3392 MX2X1 $PINS S0=FE_OFN5687_FE_RN_5 B=FE_OFN5606_a_cnt_9 A=caddr_rd[9]
+ Y=n3682
XU3393 MX2X1 $PINS S0=FE_OFN5641_FE_RN_194_0 B=FE_OFN5605_a_cnt_10 A=iaddr[10]
+ Y=n3695
XU3396 NAND2X2 $PINS A=FE_OFN5775_n5319 B=FE_OFN5549_register_3__10 Y=n5396
XU3397 NAND2X1 $PINS A=FE_OFN5547_register_3__14 B=FE_OFN5920_N608 Y=n4921
XU3400 OR3XL $PINS A=n5659 B=register[7][11] C=FE_OFN5580_register_7__12
+ Y=n5658
XU3403 XOR2X1 $PINS A=FE_OFN6008_register_3__19 B=n5259 Y=N633
XU3404 AOI31X1 $PINS A0=n4443 A1=n4374 A2=n4444 B0=n4445 Y=n4442
XU3409 AOI211X1 $PINS A0=n4486 A1=FE_OFN5603_n5235 B0=n4340 C0=n4305 Y=n4485
XU3410 MX2X1 $PINS S0=FE_OFN5641_FE_RN_194_0 B=FE_OFN5604_a_cnt_11 A=iaddr[11]
+ Y=n3696
XU3411 MX2X1 $PINS S0=FE_OFN5685_FE_RN_5 B=FE_OFN5594_N8543 A=caddr_rd[0]
+ Y=n3685
XU3412 AND2X2 $PINS A=n4955 B=n4956 Y=n4925
XU3415 AOI21X1 $PINS A0=FE_OFN75_register_3__16 A1=FE_DBTN29_N610 B0=n5522
+ Y=n5524
XU3416 NAND3X2 $PINS A=n6773 B=FE_OFN5790_register_0__13
+ C=FE_OFN5518_register_0__12 Y=n5766
XU3418 NOR2X1 $PINS A=n6708 B=n4400 Y=n4627
XU3420 NAND2X4 $PINS A=FE_OFN5645_n5531 B=n4406 Y=n5328
XU3421 AOI222X1 $PINS A0=FE_OFN5568_register_6__11 A1=FE_OCPN6203_n5238
+ B0=CMF1[11] B1=FE_OFN5653_n4656 C0=register[7][11] C1=FE_OCPN6200_n5237 Y=n5888
XU3422 AOI22X1 $PINS A0=n6775 A1=n6678 B0=n6634 B1=n6680 Y=n4598
XU3425 AOI22X1 $PINS A0=FE_OFN5958_n5004 A1=CMF1[35] B0=FE_OFN5663_n4999
+ B1=cdata_wr[19] Y=n4262
XU3426 MX2X1 $PINS S0=FE_OFN5687_FE_RN_5 B=FE_OFN5604_a_cnt_11 A=caddr_rd[11]
+ Y=n3684
XU3427 MX2X1 $PINS S0=FE_OFN5641_FE_RN_194_0 B=FE_OFN5594_N8543 A=iaddr[0]
+ Y=n3697
XU3428 NAND2X1 $PINS A=FE_OFN5857_n4910 B=CMF1[33] Y=n4923
XU3429 OAI211X1 $PINS A0=FE_DBTN79_register_5_5 A1=n5426 B0=n5413 C0=n5412
+ Y=n1836
XU3434 AOI221XL $PINS A0=n5260 A1=n4398 B0=n4400 B1=n4399 C0=n6641 Y=n4402
XU3437 INVX1 $PINS A=r_cnt[3] Y=n6718
XU3441 OR2X2 $PINS A=register[0][9] B=n5776 Y=n5252
XU3443 OR2X2 $PINS A=register[5][13] B=n5555 Y=n5554
XU3444 XOR2X2 $PINS A=n5555 B=register[5][13] Y=r2236/DIFF[13]
XU3446 XOR2X1 $PINS A=n5559 B=register[5][8] Y=r2236/DIFF[8]
XU3447 INVX1 $PINS A=n5781 Y=n5210
XU3448 NOR2X4 $PINS A=n4559 B=FE_OCPN2345_n6634 Y=n4535
XU3449 INVX1 $PINS A=n4482 Y=n6696
XU3450 OAI2BB1X1 $PINS A0N=N1701 A1N=n5812 B0=n5804 Y=n5811
XU3451 NAND2X2 $PINS A=n195 B=FE_OFN6159_n6762 Y=n5169
XU3454 OR2X2 $PINS A=FE_OFN6049_register_0__14 B=n5772 Y=n5771
XU3455 AND2X2 $PINS A=n102 B=n5011 Y=n5181
XU3456 AND4X2 $PINS A=N14811 B=N14810 C=N14809 D=N14808 Y=n4644
XU3457 XOR2X2 $PINS A=n5774 B=FE_OFN5901_register_0__12 Y=n5250
XU3460 NAND2XL $PINS A=n4340 B=n6695 Y=n4304
XU3461 NOR2XL $PINS A=n6688 B=n6695 Y=n4301
XU3463 NOR3X1 $PINS A=n6695 B=flag[2] C=n6693 Y=n5235
XU3464 OR2X4 $PINS A=register[7][17] B=n5652 Y=n5651
XU3465 OR2X2 $PINS A=FE_OCPN6229_N1281 B=FE_OFN5804_N1316 Y=n5564
XU3466 AND3X2 $PINS A=FE_OFN5546_register_3__16 B=FE_OFN6017_register_3__17
+ C=n5283 Y=n5282
XU3467 AND2X2 $PINS A=n5282 B=FE_OFN5813_register_3__18 Y=n5259
XU3468 OR2X2 $PINS A=register[7][11] B=n5659 Y=n5248
XU3469 NAND2X1 $PINS A=n5818 B=n5817 Y=N1734
XU3471 OR2X2 $PINS A=FE_OFN5561_register_5__12 B=n5556 Y=n5555
XU3472 NAND2X2 $PINS A=n5178 B=n5019 Y=n5119
XU3473 NAND2X2 $PINS A=n98 B=FE_OFN6166_n5011 Y=n4951
XU3477 NAND2X1 $PINS A=n4915 B=FE_OFN5562_register_5__10 Y=n4917
XU3478 INVX1 $PINS A=n5247 Y=n4915
XU3479 NAND2X1 $PINS A=n4918 B=n5184 Y=n5017
XU3480 NAND2X1 $PINS A=n103 B=n5011 Y=n5184
XU3481 AND3X4 $PINS A=n4919 B=n4920 C=n4921 Y=n4829
XU3482 CLKINVX3 $PINS A=n5405 Y=n6655
XU3483 NAND2X4 $PINS A=n99 B=FE_OFN6166_n5011 Y=n4922
XU3484 NAND2X1 $PINS A=n59 B=n5272 Y=n4924
XU3486 NAND2X2 $PINS A=n4925 B=n4954 Y=n4940
XU3487 NAND2X1 $PINS A=FE_OFN5857_n4910 B=CMF1[35] Y=n4955
XU3488 NAND2X1 $PINS A=n57 B=n5272 Y=n4956
XU3489 XOR2X2 $PINS A=n5772 B=FE_OFN6049_register_0__14 Y=r2257/DIFF[14]
XU3493 INVX1 $PINS A=n5683 Y=n1676
XU3494 AOI222X1 $PINS A0=CMF0[22] A1=FE_OFN5644_n4911 B0=n205 B1=n5009 C0=n90
+ C1=n5275 Y=n5687
XU3495 AOI222X1 $PINS A0=FE_OFN5857_n4910 A1=CMF1[26] B0=n5011 B1=n106 C0=n66
+ C1=n5272 Y=n5826
XU3501 AOI222X1 $PINS A0=CMF0[23] A1=FE_OFN5644_n4911 B0=n204 B1=n5009 C0=n89
+ C1=n5275 Y=n5686
XU3506 XOR2X1 $PINS A=n5554 B=register[5][14] Y=r2236/DIFF[14]
XU3508 NOR4X1 $PINS A=n5285 B=N14808 C=N14809 D=N14807 Y=n4443
XU3510 NAND2X1 $PINS A=FE_OFN5707_register_3__17 B=FE_OFN89_N611 Y=n4944
XU3511 INVX4 $PINS A=n5422 Y=n6654
XU3512 OR2X2 $PINS A=FE_DBTN29_N610 B=FE_OFN75_register_3__16 Y=n4819
XU3514 XOR2X1 $PINS A=FE_OFN5813_register_3__18 B=n5282 Y=N632
XU3515 INVX1 $PINS A=N1705 Y=n5787
XU3516 INVX1 $PINS A=N1702 Y=n5804
XU3529 INVX1 $PINS A=r_cnt[1] Y=n6719
XU3530 INVX1 $PINS A=flag[0] Y=n6693
XU3531 INVX1 $PINS A=flag[1] Y=n6695
XU3537 NOR2X4 $PINS A=n4536 B=n4619 Y=n4621
XU3539 INVX1 $PINS A=register[7][11] Y=n5655
XU3542 INVX1 $PINS A=CMF1[31] Y=n5147
XU3544 NOR2X4 $PINS A=n6690 B=FE_OFN5677_n5350 Y=n5001
XU3549 NOR2X4 $PINS A=n6690 B=FE_OFN5677_n5350 Y=n5005
XU3550 INVXL $PINS A=FE_OFN5581_register_7__5 Y=n5621
XU3554 OAI222XL $PINS A0=n5085 A1=n5332 B0=n5212 B1=n5507
+ C0=FE_OFN388_register_0__11 C1=n5435 Y=n1876
XU3556 AOI222X4 $PINS A0=n129 A1=FE_OFN5978_n5340 B0=n5341 B1=n4939 C0=FE_RN_6
+ C1=register[5][3] Y=n5905
XU3557 AOI222X4 $PINS A0=n121 A1=FE_OFN5978_n5340 B0=n5341
+ B1=FE_OFN5865_register_4__11 C0=n5342 C1=register[5][11] Y=n5889
XU3559 AOI222X1 $PINS A0=CMF0[20] A1=FE_OFN5644_n4911 B0=n207 B1=n5009 C0=n92
+ C1=n5275 Y=n5689
XU3560 AOI222X1 $PINS A0=FE_OCPN6193_n5223 A1=FE_OFN5765_register_3__14
+ B0=FE_OFN5612_CMF0_14 B1=FE_OCPN6248_FE_DBTN1185_n4720 C0=FE_OFN6151_n5224
+ C1=FE_DBTN1156_register_2_14 Y=n5723
XU3562 AOI222X1 $PINS A0=register[7][8] A1=FE_OCPN6200_n5237 B0=CMF1[8]
+ B1=FE_OFN5653_n4656 C0=FE_OFN5830_register_6__8 C1=FE_OCPN6203_n5238 Y=n5894
XU3564 AOI222X4 $PINS A0=n122 A1=FE_OFN5978_n5340 B0=n5341
+ B1=FE_DBTN96_register_4_10 C0=n5342 C1=FE_OFN5562_register_5__10 Y=n5891
XU3565 AOI222X4 $PINS A0=n132 A1=FE_OFN5978_n5340 B0=n5341 B1=register[4][0]
+ C0=N1315 C1=FE_RN_6 Y=n5912
XU3566 NAND2X1 $PINS A=FE_OFN5857_n4910 B=CMF1[28] Y=n4946
XU3567 NAND2X1 $PINS A=n64 B=n5272 Y=n4948
XU3568 NAND2X1 $PINS A=n104 B=n5011 Y=n4947
XU3569 OR2X2 $PINS A=FE_OCPN6243_n5834 B=n5147 Y=n4949
XU3570 OR2X2 $PINS A=n5150 B=FE_OFN6082_n5272 Y=n4950
XU3571 NAND2X1 $PINS A=FE_OFN5857_n4910 B=CMF1[34] Y=n4952
XU3572 NAND2X1 $PINS A=n58 B=n5272 Y=n4953
XU3575 INVX1 $PINS A=register[5][11] Y=n5530
XU3577 OR2X1 $PINS A=N14808 B=N14809 Y=n4933
XU3581 INVX1 $PINS A=register[7][4] Y=n4945
XU3582 AND2X2 $PINS A=n5157 B=n5158 Y=n4934
XU3583 NAND3X1 $PINS A=n4946 B=n4947 C=n4948 Y=n4936
XU3585 INVX1 $PINS A=CMF0[31] Y=n5127
XU3586 INVX1 $PINS A=n81 Y=n5130
XU3587 NAND2X1 $PINS A=n5217 B=FE_OFN5721_register_5__4 Y=n5221
XU3589 INVX1 $PINS A=N1703 Y=n5801
XU3590 XOR2X2 $PINS A=n5660 B=FE_OFN5661_register_7__10 Y=n5280
XU3591 NAND2X2 $PINS A=n5156 B=n4934 Y=n5131
XU3592 XOR2X1 $PINS A=n5779 B=register[0][6] Y=r2257/DIFF[6]
XU3593 NAND4X1 $PINS A=N1698 B=N1696 C=N1697 D=n5807 Y=n5817
XU3597 OR2X2 $PINS A=FE_OFN5559_register_5__16 B=n5553 Y=n5552
XU3598 XOR2X4 $PINS A=n5553 B=FE_OFN5559_register_5__16 Y=r2236/DIFF[16]
XU3599 OR2X2 $PINS A=register[5][14] B=n5554 Y=n5255
XU3601 INVX2 $PINS A=n5914 Y=n5913
XU3603 INVX1 $PINS A=n5812 Y=n5803
XU3605 NOR2X2 $PINS A=N1704 B=N1703 Y=n5264
XU3607 XNOR2X2 $PINS A=n5668 B=FE_OFN5581_register_7__5 Y=n5286
XU3609 OR2X2 $PINS A=n5802 B=n4941 Y=n5794
XU3611 CLKINVX3 $PINS A=n196 Y=n5128
XU3612 XOR2X1 $PINS A=n5556 B=FE_OFN5561_register_5__12 Y=r2236/DIFF[12]
XU3614 NAND2X1 $PINS A=n5210 B=FE_OFN5761_register_0__3 Y=n5211
XU3615 NAND2X1 $PINS A=n200 B=n5009 Y=n5166
XU3616 OAI2BB1X2 $PINS A0N=n5525 A1N=FE_OFN5747_N609 B0=n4827 Y=n5422
XU3618 NAND2X1 $PINS A=FE_OFN75_register_3__16 B=FE_DBTN29_N610 Y=n4942
XU3619 NAND2X1 $PINS A=n4819 B=n6654 Y=n4943
XU3620 AND3X2 $PINS A=n4942 B=n4943 C=n4944 Y=n4818
XU3621 OR3XL $PINS A=N14807 B=n5285 C=n4933 Y=n6653
XU3622 NAND2X4 $PINS A=n97 B=FE_OFN6166_n5011 Y=n4954
XU3624 INVX1 $PINS A=n5287 Y=n4387
XU3625 AOI2BB2X1 $PINS A0N=n5925 A1N=n5212 B0=FE_OCPN6255_n5001 B1=cdata_rd[11]
+ Y=n5455
XU3626 OR2X4 $PINS A=N1695 B=n5816 Y=n5807
XU3627 AND3X2 $PINS A=n5811 B=n5810 C=n5809 Y=N1738
XU3628 OR2X4 $PINS A=n5813 B=n5802 Y=n5810
XU3630 NAND4X1 $PINS A=n6696 B=n6642 C=FE_OFN5651_n4638 D=n6653 Y=n4410
XU3631 NAND2X1 $PINS A=N14807 B=n4637 Y=n4638
XU3633 NAND2X1 $PINS A=n5115 B=n5807 Y=N1731
XU3634 INVX1 $PINS A=n5789 Y=n5788
XU3635 OAI2BB1X2 $PINS A0N=n5521 A1N=FE_OFN5936_N612 B0=n4816 Y=n5914
XU3636 OAI21X1 $PINS A0=FE_OFN5936_N612 A1=n5521 B0=FE_OFN5813_register_3__18
+ Y=n4816
XU3637 NAND2X1 $PINS A=FE_OFN5548_register_3__11 B=n5278 Y=n5174
XU3638 XOR2X2 $PINS A=n5135 B=register[0][7] Y=r2257/DIFF[7]
XU3639 OR2X4 $PINS A=n4818 B=n5249 Y=n5521
XU3640 NAND4X2 $PINS A=n5794 B=n5810 C=n5264 D=n5787 Y=n5795
XU3641 XOR2XL $PINS A=n4810 B=FE_OFN5549_register_3__10 Y=N624
XU3642 NAND2XL $PINS A=n4810 B=FE_OFN5549_register_3__10 Y=n5278
XU3643 OAI21X1 $PINS A0=n5913 A1=n4808 B0=n6714 Y=n4810
XU3645 INVX2 $PINS A=N1698 Y=n5806
XU3646 AOI21X1 $PINS A0=n4399 A1=n6708 B0=n4655 Y=n4629
XU3648 AND4X2 $PINS A=N14813 B=N14814 C=N14815 D=n6697 Y=n4797
XU3649 NOR2X4 $PINS A=n6639 B=n6690 Y=n4632
XU3651 INVX1 $PINS A=n4479 Y=n6700
XU3654 INVX1 $PINS A=n5288 Y=n4384
XU3655 NOR2X1 $PINS A=n4399 B=n6645 Y=n4358
XU3661 AND2X2 $PINS A=n4786 B=n6707 Y=n5224
XU3665 INVX1 $PINS A=n5008 Y=n5217
XU3667 INVX1 $PINS A=n4808 Y=n5510
XU3668 NOR2X1 $PINS A=n5514 B=n5513 Y=n5013
XU3669 XOR2X1 $PINS A=FE_OFN6017_register_3__17 B=n5511 Y=N631
XU3670 XNOR2X1 $PINS A=FE_OCPN6210_register_3__15 B=n5277 Y=N629
XU3671 XOR2X1 $PINS A=FE_OFN5765_register_3__14 B=n5013 Y=N628
XU3672 NOR2X1 $PINS A=FE_OFN262_register_7__10 B=register[7][15] Y=n5648
XU3673 INVX1 $PINS A=N1707 Y=n5791
XU3674 INVX1 $PINS A=N1700 Y=n5813
XU3675 XOR2X1 $PINS A=n5795 B=N1706 Y=N1742
XU3676 OAI2BB1X1 $PINS A0N=N1708 A1N=n5790 B0=n5789 Y=N1744
XU3679 NAND3X1 $PINS A=n4410 B=n4395 C=n4358 Y=n4519
XU3680 NAND2X1 $PINS A=n5176 B=n4629 Y=n4445
XU3681 OR2X4 $PINS A=n5834 B=n5833 Y=n5843
XU3683 OR2X2 $PINS A=n5691 B=n5690 Y=n5695
XU3685 INVX1 $PINS A=c_cnt[12] Y=n6697
XU3686 INVX1 $PINS A=N14817 Y=n6713
XU3687 OR3XL $PINS A=N14815 B=c_cnt[11] C=N14816 Y=n5242
XU3688 INVX1 $PINS A=CMF1[35] Y=n5842
XU3690 AOI211X1 $PINS A0=n5288 A1=n4523 B0=n6653 C0=n4316 Y=n4441
XU3694 OAI31X4 $PINS A0=n4445 A1=n4526 A2=n4527 B0=FE_OFN5946_FE_DBTN7_n5276
+ Y=n4449
XU3705 OAI221XL $PINS A0=n6702 A1=n4358 B0=n4359 B1=N425 C0=n4360 Y=n4357
XU3709 NOR2X1 $PINS A=n6706 B=r_cnt[3] Y=n4486
XU3715 INVX1 $PINS A=FE_OFN5523_register_1__13 Y=n5490
XU3722 INVX1 $PINS A=FE_OFN5524_register_1__9 Y=n5494
XU3724 NAND2X2 $PINS A=n5352 B=n4406 Y=n5231
XU3726 NAND2X4 $PINS A=FE_OFN5603_n5235 B=FE_OCPN2279_FE_RN_29 Y=n5232
XU3727 NAND2X4 $PINS A=FE_OFN5796_n4440 B=n5347 Y=n5227
XU3730 NAND2X1 $PINS A=FE_OFN6095_n4911 B=n5117 Y=n5157
XU3731 NAND2X1 $PINS A=n77 B=FE_OFN5974_n5275 Y=n5158
XU3733 AOI222X1 $PINS A0=FE_OFN5984_register_6__15 A1=FE_OCPN6203_n5238
+ B0=CMF1[15] B1=FE_OFN5653_n4656 C0=register[7][15] C1=FE_OCPN6199_n5237 Y=n5822
XU3738 NAND2X1 $PINS A=n5677 B=n5676 Y=n1687
XU3739 AOI222X1 $PINS A0=FE_OCPN6210_register_3__15 A1=FE_OCPN6193_n5223
+ B0=FE_OFN5611_CMF0_15 B1=FE_OCPN6248_FE_DBTN1185_n4720 C0=FE_OFN6151_n5224
+ C1=FE_OFN5533_register_2__15 Y=n5676
XU3741 AOI222X1 $PINS A0=n224 A1=FE_OFN6130_n5000 B0=FE_OFN5761_register_0__3
+ B1=FE_OFN6125_n5007 C0=FE_OCPN6247_n C1=FE_OFN5528_register_1__3 Y=n5746
XU3743 AOI222X1 $PINS A0=FE_OFN5544_register_2__1 A1=FE_OFN6151_n5224
+ B0=CMF0[1] B1=FE_OCPN6248_FE_DBTN1185_n4720 C0=FE_OFN6040_N1177
+ C1=FE_OCPN6193_n5223 Y=n5749
XU3744 AOI222X1 $PINS A0=FE_OFN5787_register_2__6 A1=FE_OFN6151_n5224
+ B0=CMF0[6] B1=FE_OCPN6248_FE_DBTN1185_n4720 C0=FE_OCPN6193_n5223
+ C1=FE_OFN5591_N610 Y=n5739
XU3749 AOI222X2 $PINS A0=FE_OCPN2346_n5238 A1=register[6][14] B0=CMF1[14]
+ B1=FE_OFN5653_n4656 C0=FE_OCPN6199_n5237 C1=FE_OFN5578_register_7__14 Y=n5882
XU3750 AOI222X4 $PINS A0=n118 A1=FE_OFN5978_n5340 B0=n5341
+ B1=FE_OFN5745_register_4__14 C0=n5342 C1=register[5][14] Y=n5883
XU3751 NAND2X1 $PINS A=FE_OFN6094_n4911 B=CMF0[27] Y=n5165
XU3752 NAND2X1 $PINS A=n85 B=n5275 Y=n5167
XU3753 AOI222X2 $PINS A0=FE_OFN6151_n5224 A1=FE_OFN5536_register_2__12
+ B0=FE_OFN5614_CMF0_12 B1=FE_OCPN6248_FE_DBTN1185_n4720 C0=register[3][12]
+ C1=FE_OCPN6193_n5223 Y=n5727
XU3755 AOI222X1 $PINS A0=FE_OFN6151_n5224 A1=FE_OFN5535_register_2__13
+ B0=FE_OFN5613_CMF0_13 B1=FE_OCPN6248_FE_DBTN1185_n4720 C0=FE_OCPN6193_n5223
+ C1=n5108 Y=n5725
XU3756 AOI222X1 $PINS A0=n214 A1=FE_OFN6130_n5000 B0=register[0][13]
+ B1=FE_OFN6125_n5007 C0=FE_OFN5523_register_1__13 C1=FE_OCPN6195_n5002 Y=n5726
XU3757 AOI222X1 $PINS A0=FE_OFN5543_register_2__4 A1=FE_OFN6151_n5224
+ B0=CMF0[4] B1=FE_OCPN6248_FE_DBTN1185_n4720 C0=FE_OCPN6193_n5223
+ C1=FE_DBTN31_N608 Y=n5743
XU3759 NAND2X1 $PINS A=n5903 B=n5902 Y=n1692
XU3760 AOI222X1 $PINS A0=FE_OFN262_register_7__10 A1=FE_OCPN6200_n5237
+ B0=CMF1[10] B1=FE_OFN5653_n4656 C0=register[6][10] C1=FE_OCPN6203_n5238 Y=n5890
XU3762 AOI222X2 $PINS A0=n217 A1=FE_OFN6130_n5000 B0=register[0][10]
+ B1=FE_OFN6125_n5007 C0=FE_OFN6003_register_1__10 C1=FE_OCPN6195_n5002 Y=n5732
XU3764 AOI222X1 $PINS A0=FE_OFN6151_n5224 A1=N15861 B0=CMF0[0]
+ B1=FE_OCPN6248_FE_DBTN1185_n4720 C0=FE_OCPN6193_n5223 C1=FE_OFN5775_n5319
+ Y=n5752
XU3767 INVX1 $PINS A=CMF1[32] Y=n5152
XU3768 INVX1 $PINS A=n60 Y=n5154
XU3769 NAND2X1 $PINS A=FE_OFN5857_n4910 B=CMF1[29] Y=n5183
XU3770 NAND2X1 $PINS A=n63 B=n5272 Y=n5185
XU3771 NAND2X1 $PINS A=FE_OFN6095_n4911 B=CMF0[29] Y=n5171
XU3772 NAND2X1 $PINS A=n83 B=FE_OFN5974_n5275 Y=n5173
XU3773 OAI222XL $PINS A0=n5097 A1=n5332 B0=n5504 B1=n5507 C0=n5503 C1=n5435
+ Y=n1866
XU3774 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=n5672 B0=FE_OFN5655_n6755
+ B1=FE_DBTN1179_N872 C0=FE_OCPN6260_n5230 C1=n5097 Y=n1765
XU3775 INVX1 $PINS A=n61 Y=n5150
XU3776 OAI222XL $PINS A0=FE_OFN205_i_cdata_rd_3 A1=n5332
+ B0=FE_DBTN130_register_1_3 B1=n5334 C0=FE_DBTN137_register_0_3 C1=n5435 Y=n1868
XU3779 XOR2X1 $PINS A=n5562 B=register[5][5] Y=r2236/DIFF[5]
XU3780 AOI222X4 $PINS A0=n127 A1=FE_OFN5978_n5340 B0=FE_DBTN91_register_4_5
+ B1=n5341 C0=register[5][5] C1=n5342 Y=n5901
XU3781 NAND3XL $PINS A=n6740 B=N1694 C=N1695 Y=n5115
XU3784 OR4X2 $PINS A=n5109 B=FE_OFN6049_register_0__14 C=n5766
+ D=FE_OFN6019_register_0__11 Y=n5770
XU3786 INVX1 $PINS A=FE_OFN5519_register_1__19 Y=n4988
XU3788 NOR2X4 $PINS A=FE_OFN176_n5348 B=n6690 Y=n5226
XU3795 NOR2X2 $PINS A=FE_OFN5656_n4720 B=n5835 Y=n5000
XU3797 NAND2X4 $PINS A=FE_OFN5603_n5235 B=n5352 Y=n5003
XU3798 NOR3X1 $PINS A=n6695 B=flag[2] C=FE_OFN5662_n4999 Y=n5004
XU3799 NOR2X4 $PINS A=FE_RN_16 B=n6690 Y=n5006
XU3801 OR2X2 $PINS A=FE_OFN5743_register_5__3 B=n5563 Y=n5008
XU3803 NOR2X2 $PINS A=FE_OFN5951_n4226 B=n4245 Y=n5010
XU3804 AND3X4 $PINS A=n5844 B=FE_OFN6146_n4911 C=n5116 Y=n5275
XU3811 NAND3X1 $PINS A=n5162 B=n5163 C=n5164 Y=n5014
XU3812 NAND3X1 $PINS A=n5165 B=n5166 C=n5167 Y=n5015
XU3814 AND2X2 $PINS A=FE_RN_29 B=n4441 Y=n5018
XU3815 AND2X2 $PINS A=n5177 B=n5179 Y=n5019
XU3816 AND2X2 $PINS A=n5159 B=n5161 Y=n5020
XU3819 NAND2X1 $PINS A=n6663 B=n4347 Y=n4226
XU3820 CLKINVX3 $PINS A=idata[0] Y=n5021
XU3822 INVX2 $PINS A=idata[1] Y=n5023
XU3826 INVX2 $PINS A=idata[3] Y=n5027
XU3828 INVX2 $PINS A=idata[4] Y=n5029
XU3830 INVX2 $PINS A=idata[5] Y=n5031
XU3832 INVX2 $PINS A=idata[6] Y=n5033
XU3840 CLKINVX3 $PINS A=idata[10] Y=n5041
XU3844 CLKINVX3 $PINS A=idata[12] Y=n5045
XU3846 INVX2 $PINS A=idata[13] Y=n5047
XU3848 INVX2 $PINS A=idata[14] Y=n5049
XU3850 CLKINVX3 $PINS A=idata[15] Y=n5051
XU3852 CLKINVX3 $PINS A=idata[16] Y=n5053
XU3854 CLKINVX3 $PINS A=idata[17] Y=n5055
XU3856 INVX2 $PINS A=idata[18] Y=n5057
XU3858 INVX2 $PINS A=idata[19] Y=n5059
XU3860 INVX2 $PINS A=cdata_rd[4] Y=n5061
XU3862 INVX2 $PINS A=cdata_rd[5] Y=n5063
XU3864 INVX2 $PINS A=cdata_rd[10] Y=n5065
XU3866 INVX2 $PINS A=cdata_rd[17] Y=n5067
XU3868 INVX2 $PINS A=cdata_rd[18] Y=n5069
XU3870 INVX2 $PINS A=cdata_rd[19] Y=n5071
XU3878 INVX2 $PINS A=cdata_rd[7] Y=n5079
XU3880 INVX2 $PINS A=cdata_rd[8] Y=n5081
XU3882 INVX2 $PINS A=cdata_rd[9] Y=n5083
XU3884 INVX2 $PINS A=cdata_rd[11] Y=n5085
XU3886 INVX2 $PINS A=cdata_rd[12] Y=n5087
XU3888 INVX2 $PINS A=cdata_rd[13] Y=n5089
XU3890 INVX2 $PINS A=cdata_rd[14] Y=n5091
XU3892 INVX2 $PINS A=cdata_rd[15] Y=n5093
XU3894 INVX2 $PINS A=cdata_rd[16] Y=n5095
XU3896 INVX2 $PINS A=cdata_rd[1] Y=n5097
XU3901 NAND2X1 $PINS A=n199 B=n5009 Y=n5163
XU3902 INVX1 $PINS A=n5101 Y=n5103
XU3907 NAND2BX4 $PINS AN=n5135 B=FE_OCPN6222_n5279 Y=n5109
XU3908 AOI21X2 $PINS A0=n5517 A1=FE_DBTN1171_register_3_12 B0=n5520 Y=N626
XU3909 OR2X2 $PINS A=FE_OFN5761_register_0__3 B=n5781 Y=n5780
XU3910 NAND2X2 $PINS A=n6740 B=N1694 Y=n5805
XU3911 NAND3X1 $PINS A=n5284 B=FE_DBTN53_register_7_3
+ C=FE_OFN5689_register_7__2 Y=n5647
XU3912 NAND3XL $PINS A=FE_OFN5549_register_3__10 B=FE_OFN5548_register_3__11
+ C=n5510 Y=n5519
XU3915 NAND2BX1 $PINS AN=N1618 B=n5503 Y=n5110
XU3917 NAND2X1 $PINS A=FE_OFN6095_n4911 B=n5112 Y=n5177
XU3918 NAND2X1 $PINS A=n79 B=FE_OFN5974_n5275 Y=n5179
XU3919 OR2X2 $PINS A=FE_OFN6019_register_0__11 B=n5109 Y=n5774
XU3920 OR2X2 $PINS A=register[0][7] B=n5135 Y=n5777
XU3921 OR2X4 $PINS A=N1698 B=n5262 Y=n5786
XU3923 OR2X2 $PINS A=FE_OFN5896_register_7__7 B=n5666 Y=n5665
XU3925 NAND2XL $PINS A=n4386 B=n6622 Y=n4414
XU3926 NOR4X1 $PINS A=n5242 B=N14813 C=N14814 D=n6653 Y=n4354
XU3927 AOI222X1 $PINS A0=FE_OFN6094_n4911 A1=CMF0[26] B0=n201 B1=n5009 C0=n86
+ C1=n5275 Y=n5683
XU3928 OR2X2 $PINS A=FE_OFN5579_register_7__13 B=n5658 Y=n5657
XU3929 OR2X2 $PINS A=register[7][18] B=n5651 Y=n5650
XU3930 CLKINVX3 $PINS A=N1692 Y=n5784
XU3931 NAND2X1 $PINS A=n5160 B=n5020 Y=n5132
XU3932 NAND2X1 $PINS A=FE_OFN6095_n4911 B=n5118 Y=n5159
XU3933 NAND2X1 $PINS A=n78 B=FE_OFN5974_n5275 Y=n5161
XU3934 NAND3X1 $PINS A=n5806 B=n5820 C=n5805 Y=n5785
XU3935 INVX1 $PINS A=n5684 Y=n4869
XU3936 AOI222X1 $PINS A0=CMF0[25] A1=FE_OFN6094_n4911 B0=n202 B1=n5009 C0=n87
+ C1=n5275 Y=n5684
XU3938 NAND2BX1 $PINS AN=N1618 B=n5503 Y=n5782
XU3939 AOI2BB2X1 $PINS A0N=FE_OFN5960_n5348 A1N=FE_DBTN59_register_7_15
+ B0=cdata_rd[15] B1=n5226 Y=n5584
XU3941 OR2X4 $PINS A=n5779 B=register[0][6] Y=n5135
XU3942 OR2X2 $PINS A=FE_OFN5564_register_5__7 B=n5560 Y=n5559
XU3944 OAI21X1 $PINS A0=FE_OFN6087_n5396 A1=FE_OFN6039_N1177 B0=n4841 Y=n4837
XU3945 OAI2BB1X2 $PINS A0N=FE_OFN6039_N1177 A1N=FE_OFN6087_n5396
+ B0=FE_DBTN1184_register_3_11 Y=n4841
XU3946 AOI2BB2X1 $PINS A0N=n5351 A1N=n5504 B0=n5001 B1=cdata_rd[1] Y=n5480
XU3947 INVX1 $PINS A=n4837 Y=n5529
XU3949 OAI2BB1X1 $PINS A0N=n4837 A1N=FE_OFN349_N606 B0=register[3][12] Y=n4838
XU3950 AOI2BB2X1 $PINS A0N=FE_OFN5678_n5350 A1N=FE_OFN5928_n5502 B0=n5005
+ B1=cdata_rd[2] Y=n5478
XU3951 OR2X2 $PINS A=register[0][16] B=n5770 Y=n5769
XU3952 OR2X2 $PINS A=register[5][8] B=n5559 Y=n5558
XU3953 XOR2X4 $PINS A=n5770 B=register[0][16] Y=r2257/DIFF[16]
XU3954 XOR2X4 $PINS A=n5252 B=register[0][10] Y=r2257/DIFF[10]
XU3956 OR4X4 $PINS A=FE_OFN5850_FE_DBTN21_N1711 B=FE_OFN5581_register_7__5
+ C=n5647 D=n5646 Y=n5660
XU3957 NAND4X4 $PINS A=FE_DBTN54_register_7_9 B=n5644 C=n5643 D=n5642 Y=n5646
XU3958 NOR3X1 $PINS A=n6644 B=n4443 C=n6696 Y=n4399
XU3959 XOR2X2 $PINS A=n5776 B=register[0][9] Y=r2257/DIFF[9]
XU3960 XOR2X2 $PINS A=n5769 B=FE_DBTN1170_register_0_17 Y=r2257/DIFF[17]
XU3961 OR2X2 $PINS A=register[0][13] B=n5773 Y=n5772
XU3962 AOI2BB2X1 $PINS A0N=FE_OCPN6191_n5348 A1N=n5672 B0=n5226 B1=cdata_rd[1]
+ Y=n5633
XU3963 NAND2X2 $PINS A=FE_RN_15 B=FE_OFN5698_n4560 Y=n4540
XU3965 AOI222X1 $PINS A0=CMF1[25] A1=FE_OFN5857_n4910 B0=n5011 B1=n107 C0=n67
+ C1=n5272 Y=n5827
XU3968 NAND4X4 $PINS A=n5284 B=FE_OFN5689_register_7__2
+ C=FE_DBTN53_register_7_3 D=N965 Y=n5668
XU3969 NOR2X2 $PINS A=register[7][1] B=register[7][4] Y=n5284
XU3970 CLKINVX3 $PINS A=N1691 Y=n6660
XU3971 XOR2X4 $PINS A=n5670 B=register[7][3] Y=n5244
XU3972 OR2X4 $PINS A=register[7][2] B=n5671 Y=n5670
XU3974 OR2X2 $PINS A=FE_OFN5901_register_0__12 B=n5774 Y=n5773
XU3976 XOR2X1 $PINS A=n5812 B=N1701 Y=N1737
XU3977 XOR2X4 $PINS A=n5652 B=register[7][17] Y=r2240/DIFF[17]
XU3981 OR2X2 $PINS A=n5113 B=n5782 Y=n5781
XU3982 OAI31X4 $PINS A0=n5815 A1=FE_DBTN25_N1699 A2=n5813 B0=n5812 Y=N1736
XU3984 OR2X2 $PINS A=n5777 B=register[0][8] Y=n5776
XU3985 OR2X2 $PINS A=n5659 B=n5653 Y=n5654
XU3987 OR2X4 $PINS A=FE_OFN5565_register_5__6 B=n5561 Y=n5560
XU3988 XOR2X2 $PINS A=n5768 B=FE_OFN5516_register_0__18 Y=r2257/DIFF[18]
XU3989 OR2X4 $PINS A=register[5][18] B=n5551 Y=n5550
XU3990 OR2X2 $PINS A=register[5][17] B=n5552 Y=n5551
XU3991 OR2X2 $PINS A=n5768 B=FE_OFN5516_register_0__18 Y=n5767
XU3992 XOR2X4 $PINS A=FE_DBTN1180_N1618 B=register[0][1] Y=r2257/DIFF[1]
XU3993 OR2X4 $PINS A=n4829 B=n5415 Y=n5525
XU3995 OR2X2 $PINS A=FE_DBTN1170_register_0_17 B=n5769 Y=n5768
XU3996 NAND2X4 $PINS A=n192 B=FE_OFN6159_n6762 Y=n5156
XU3997 NAND2X2 $PINS A=n193 B=FE_OFN6159_n6762 Y=n5160
XU3998 NAND2XL $PINS A=FE_OFN6095_n4911 B=CMF0[28] Y=n5162
XU3999 NAND2XL $PINS A=n84 B=FE_OFN5974_n5275 Y=n5164
XU4000 NAND2XL $PINS A=FE_OFN6095_n4911 B=n5111 Y=n5168
XU4001 NAND2XL $PINS A=n80 B=FE_OFN5974_n5275 Y=n5170
XU4002 OR2X1 $PINS A=n4395 B=n6700 Y=n5176
XU4003 AOI2BB1X1 $PINS A0N=n6644 A1N=n4445 B0=n4316 Y=n4440
XU4004 NAND2X2 $PINS A=n194 B=FE_OFN6159_n6762 Y=n5178
XU4005 AND2X2 $PINS A=n62 B=n5272 Y=n5182
XU4006 OR2X2 $PINS A=FE_OFN5563_register_5__9 B=n5558 Y=n5247
XU4007 OR2X2 $PINS A=n5650 B=FE_OFN5576_register_7__19 Y=n5256
XU4011 OR2X4 $PINS A=register[5][5] B=n5562 Y=n5561
XU4012 XOR2X2 $PINS A=n5561 B=FE_OFN5565_register_5__6 Y=r2236/DIFF[6]
XU4015 INVX1 $PINS A=n5214 Y=n5216
XU4016 OR2X4 $PINS A=register[0][4] B=n5780 Y=n5246
XU4017 OR2X2 $PINS A=FE_OFN5722_register_5__2 B=n5564 Y=n5563
XU4018 XOR2X1 $PINS A=n5564 B=FE_OFN5722_register_5__2 Y=r2236/DIFF[2]
XU4019 CLKINVX3 $PINS A=n5802 Y=n5808
XU4020 OAI32X1 $PINS A0=n6712 A1=n6622 A2=n6705 B0=n4386 B1=n4371 Y=n4788
XU4021 NAND2X4 $PINS A=FE_OFN5603_n5235 B=n5347 Y=n5230
XU4024 AND2X1 $PINS A=N14812 B=n4644 Y=n4637
XU4025 NOR2X1 $PINS A=n4367 B=r_cnt[3] Y=n5260
XU4026 NAND2XL $PINS A=N425 B=r_cnt[1] Y=n4368
XU4027 NOR4BX1 $PINS AN=n4796 B=N14814 C=N14815 D=N14813 Y=n4482
XU4028 NOR4BXL $PINS AN=n6713 B=c_cnt[12] C=c_cnt[11] D=N14816 Y=n4796
XU4029 NAND2BX4 $PINS AN=n5110 B=n5281 Y=n5779
XU4030 AOI22X2 $PINS A0=n4606 A1=n6630 B0=n6624 B1=n4611 Y=n4609
XU4033 XOR2X1 $PINS A=n5560 B=FE_OFN5564_register_5__7 Y=r2236/DIFF[7]
XU4035 NOR2X1 $PINS A=n4400 B=n5260 Y=n4650
XU4037 INVX1 $PINS A=n5519 Y=n5516
XU4040 OR2X4 $PINS A=FE_OFN5658_n5505 B=n5566 Y=n5507
XU4042 AOI21XL $PINS A0=n5288 A1=n4483 B0=n4374 Y=n4388
XU4043 AND2X4 $PINS A=n4718 B=n4387 Y=n5237
XU4046 AOI21XL $PINS A0=n6719 A1=N425 B0=n4390 Y=n4377
XU4048 NOR2BX2 $PINS AN=n4305 B=FE_OFN5662_n4999 Y=n4256
XU4051 XOR2X2 $PINS A=n5255 B=FE_OFN5560_register_5__15 Y=n5254
XU4052 AND3X2 $PINS A=n5512 B=FE_OCPN6210_register_3__15 C=n5271 Y=n5283
XU4053 OR3XL $PINS A=N425 B=r_cnt[1] C=n6705 Y=n5288
XU4055 NOR2BX2 $PINS AN=N1696 B=FE_DBTN26_N1697 Y=n5262
XU4056 INVXL $PINS A=N1706 Y=n5792
XU4057 NAND3XL $PINS A=N1704 B=n5812 C=n5808 Y=n5798
XU4058 NAND2X1 $PINS A=FE_OCPN2340_FE_RN_10 B=FE_RN_9 Y=n4533
XU4060 AND2X1 $PINS A=n4414 B=n5679 Y=n4406
XU4061 NOR2X2 $PINS A=n6687 B=FE_OFN459_FE_DBTN5_n4999 Y=n5228
XU4066 NAND2X1 $PINS A=FE_OFN5603_n5235 B=n5349 Y=n5229
XU4067 NOR2X1 $PINS A=FE_OFN6056_FE_RN_5 B=n4371 Y=n4394
XU4068 AOI21XL $PINS A0=n4358 A1=n6652 B0=n4396 Y=n4481
XU4069 NOR2XL $PINS A=n6710 B=n6652 Y=n4526
XU4070 NOR2X2 $PINS A=FE_OFN459_FE_DBTN5_n4999 B=n4301 Y=n5234
XU4071 AOI21XL $PINS A0=n4371 A1=n6710 B0=n4386 Y=n4385
XU4075 NOR3X1 $PINS A=n6644 B=n4443 C=n4794 Y=n4398
XU4079 OAI2BB1XL $PINS A0N=n5260 A1N=n6641 B0=n4629 Y=n4628
XU4080 AOI22X1 $PINS A0=n4932 A1=FE_RN_38_0 B0=FE_RN_17 B1=n4588 Y=n4597
XU4081 OAI22XL $PINS A0=FE_RN_15 A1=n4562 B0=n4561 B1=FE_OFN5698_n4560 Y=n4572
XU4082 AOI21X1 $PINS A0=FE_OCPN5439_FE_OFN244_n4560 A1=n4561
+ B0=FE_OFN5760_FE_RN_74_0 Y=n4577
XU4083 AOI22X2 $PINS A0=FE_RN_3 A1=n4562 B0=FE_RN_17 B1=n4580 Y=n4576
XU4085 NOR2XL $PINS A=n4794 B=n6653 Y=n4635
XU4086 AOI22XL $PINS A0=n4400 A1=n4398 B0=n4387 B1=n4399 Y=n4643
XU4088 AND2X4 $PINS A=n4718 B=n4384 Y=n5238
XU4089 AOI211X1 $PINS A0=n5679 A1=n4361 B0=FE_OFN5704_n4378 C0=n4364 Y=n4373
XU4090 AOI222XL $PINS A0=n4384 A1=n6752 B0=n6647 B1=n4362 C0=n4377 C1=n6640
+ Y=n4376
XU4091 AOI21X1 $PINS A0=FE_OFN6148_n5006 A1=n4387 B0=n5919 Y=n4344
XU4092 AOI22XL $PINS A0=n6752 A1=n4384 B0=FE_OFN5657_n4519 B1=n4362 Y=n4754
XU4093 NAND4XL $PINS A=n4344 B=n4391 C=n4392 D=n5920 Y=n4378
XU4094 AOI21X1 $PINS A0=FE_OCPN2335_FE_OFN5946_FE_DBTN7_n5276 A1=n4393 B0=n4394
+ Y=n4392
XU4095 AOI22XL $PINS A0=n5679 A1=n4361 B0=FE_OFN5603_n5235 B1=n6718 Y=n4379
XU4096 AND3X2 $PINS A=n5695 B=n5844 C=n5116 Y=n5273
XU4097 AND3X2 $PINS A=n5843 B=n5844 C=n5842 Y=n5274
XU4098 NAND2X1 $PINS A=n4792 B=n6711 Y=n4483
XU4099 NOR2XL $PINS A=FE_OFN5766_register_3__14 B=n5513 Y=n5271
XU4100 INVXL $PINS A=n4400 Y=n6710
XU4101 AOI22XL $PINS A0=n4635 A1=n5260 B0=n6703 B1=n6647 Y=n4375
XU4102 NAND4XL $PINS A=n4381 B=n6700 C=n4382 D=n4383 Y=n4361
XU4103 NOR2XL $PINS A=n4387 B=n4388 Y=n4382
XU4104 AOI211XL $PINS A0=n6647 A1=n4384 B0=n6699 C0=n4385 Y=n4383
XU4105 NOR2BX2 $PINS AN=n4303 B=FE_OFN5662_n4999 Y=n5354
XU4106 OAI22XL $PINS A0=FE_OFN5967_n4998 A1=n5023 B0=FE_OFN5957_n5634 B1=N1424
+ Y=n1767
XU4107 NAND4XL $PINS A=n4344 B=n4345 C=FE_OFN5951_n4226 D=n4346 Y=n4337
XU4108 NAND3XL $PINS A=FE_RN_1 B=n6695 C=flag[2] Y=n4345
XU4109 NOR2X2 $PINS A=FE_OFN5662_n4999 B=n4300 Y=n5239
XU4112 NOR2XL $PINS A=n6690 B=N425 Y=n4364
XU4113 OR2XL $PINS A=n4396 B=FE_DBTN1162_register_3_19 Y=n5694
XU4114 OR2XL $PINS A=n4396 B=FE_DBTN112_register_3_18 Y=n5703
XU4115 OR2XL $PINS A=n4483 B=FE_DBTN1175_register_2_19 Y=n5693
XU4116 OR2XL $PINS A=n4483 B=FE_OFN5805_register_2__17 Y=n5709
XU4117 OR2XL $PINS A=n4483 B=FE_OFN5870_register_2__18 Y=n5702
XU4118 OR2X2 $PINS A=register[7][1] B=FE_OFN5850_FE_DBTN21_N1711 Y=n5671
XU4119 OR2X2 $PINS A=register[7][6] B=n5667 Y=n5666
XU4120 AOI22XL $PINS A0=n4596 A1=FE_RN_17 B0=FE_OFN444_n5346 B1=n50 Y=n4622
XU4121 AOI21X1 $PINS A0=n4627 A1=n5288 B0=FE_OFN5398_n4534 Y=n4626
XU4122 NAND2XL $PINS A=n53 B=FE_OCPN6258_FE_OFN444_n5346 Y=n4610
XU4125 OR2X2 $PINS A=register[7][15] B=n5654 Y=n5245
XU4131 AOI22XL $PINS A0=n56 A1=n5346 B0=n4388 B1=FE_OCPN2339_FE_RN_7 Y=n4530
XU4133 AOI2BB1XL $PINS A0N=n5108 A1N=FE_OFN6168_N607 B0=n5526 Y=n5528
XU4134 NAND3XL $PINS A=n4354 B=n6713 C=c_cnt[12] Y=n4342
XU4135 AOI22X2 $PINS A0=FE_OFN5609_a_cnt_6 A1=FE_OCPN5439_FE_OFN244_n4560
+ B0=FE_RN_3 B1=n4582 Y=n4589
XU4141 OR2X4 $PINS A=n5767 B=FE_DBTN1167_register_0_19 Y=n5142
XU4142 NAND4BBX1 $PINS AN=n5721 BN=n5720 C=n5257 D=n5258 Y=n1667
XU4143 NAND2X1 $PINS A=FE_OFN101_CMF0_16 B=n5273 Y=n5257
XU4144 NAND2X1 $PINS A=n5916 B=CMF0[16] Y=n5258
XU4145 NOR2XL $PINS A=flag[1] B=flag[2] Y=n4305
XU4146 NOR3XL $PINS A=r_cnt[1] B=r_cnt[3] C=n3634 Y=n4792
XU4147 NAND3XL $PINS A=N14817 B=n6697 C=n4354 Y=n4335
XU4148 AOI2BB1XL $PINS A0N=n4368 A1N=n4358 B0=n5260 Y=n4366
XU4149 AOI21X1 $PINS A0=n4370 A1=n4368 B0=FE_OFN5704_n4378 Y=n4365
XU4150 NOR2XL $PINS A=n6695 B=flag[0] Y=n4339
XU4151 OAI2BB1XL $PINS A0N=n4335 A1N=N14832 B0=flag[2] Y=n4347
XU4152 AOI22XL $PINS A0=n5234 A1=N14808 B0=n5228 B1=N14807 Y=n4261
XU4153 AOI22XL $PINS A0=n5234 A1=N14809 B0=n5228 B1=N14808 Y=n4314
XU4154 AOI22X1 $PINS A0=n5234 A1=N14810 B0=n5228 B1=N14809 Y=n4306
XU4155 AOI22XL $PINS A0=n5234 A1=N14811 B0=n5228 B1=N14810 Y=n4307
XU4156 AOI22XL $PINS A0=n5234 A1=N14812 B0=n5228 B1=N14811 Y=n4308
XU4157 AOI22XL $PINS A0=n5234 A1=N14813 B0=n5228 B1=N14812 Y=n4309
XU4158 AOI22XL $PINS A0=n5234 A1=N14814 B0=n5228 B1=N14813 Y=n4310
XU4159 AOI22XL $PINS A0=n5234 A1=N14815 B0=n5228 B1=N14814 Y=n4311
XU4160 AOI22XL $PINS A0=n5234 A1=N14816 B0=n5228 B1=N14815 Y=n4312
XU4161 AOI22XL $PINS A0=n5234 A1=N14817 B0=n5228 B1=N14816 Y=n4313
XU4162 AOI22X1 $PINS A0=n5234 A1=c_cnt[11] B0=n5228 B1=N14817 Y=n4260
XU4163 AOI22XL $PINS A0=n5234 A1=N14807 B0=n5228 B1=N14832 Y=n4251
XU4164 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=N14807 B0=N14301 B1=n5010 Y=n4244
XU4165 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=N14813 B0=N14307 B1=n5010 Y=n4229
XU4166 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=N14814 B0=N14308 B1=n5010 Y=n4228
XU4167 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=N14815 B0=N14309 B1=n5010 Y=n4225
XU4168 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=N14816 B0=N14310 B1=n5010 Y=n4241
XU4169 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=N14817 B0=N14311 B1=n5010 Y=n4240
XU4170 NAND3BXL $PINS AN=n4352 B=FE_OCPN6242_FE_OFN6056_FE_RN_5 C=cwr Y=n4351
XU4171 AOI221XL $PINS A0=n4335 A1=flag[2] B0=n6688 B1=n4342
+ C0=FE_DBTN1182_n6663 Y=n4352
XU4172 NOR2XL $PINS A=n4368 B=n3634 Y=n4755
XU4173 NAND2XL $PINS A=FE_OCPN6242_FE_OFN6056_FE_RN_5 B=n4349 Y=n1950
XU4174 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=N14809 B0=N14303 B1=n5010 Y=n4242
XU4175 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=N14808 B0=N14302 B1=n5010 Y=n4243
XU4176 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=N14812 B0=N14306 B1=n5010 Y=n4230
XU4177 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=c_cnt[12] B0=N14313 B1=n5010
+ Y=n4238
XU4178 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=c_cnt[11] B0=N14312 B1=n5010
+ Y=n4239
XU4179 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=N14811 B0=N14305 B1=n5010 Y=n4231
XU4180 AOI22XL $PINS A0=FE_OFN5951_n4226 A1=N14810 B0=N14304 B1=n5010 Y=n4232
XU4181 AND3X1 $PINS A=FE_DBTN1182_n6663 B=n4346 C=n4490 Y=n4484
XU4182 AOI22XL $PINS A0=FE_OFN5686_FE_RN_5 A1=n4491 B0=n4340 B1=FE_RN_1 Y=n4490
XU4183 NOR3XL $PINS A=FE_RN_117_0 B=flag[2] C=n6648 Y=n4489
XU4184 AOI21XL $PINS A0=flag[2] A1=n4339 B0=n4302 Y=n4487
XU4185 OAI2BB1XL $PINS A0N=n6663 A1N=n4317 B0=busy Y=n4348
XU4186 NAND3XL $PINS A=n6663 B=n4335 C=flag[2] Y=n4334
XU4187 AND2X1 $PINS A=N14807 B=n4644 Y=n4641
XU4188 AOI22XL $PINS A0=FE_OCPN2278_FE_OFN5639_FE_RN_194_0 A1=N8545 B0=iaddr[1]
+ B1=FE_OFN5638_FE_RN_194_0 Y=n4246
XU4189 NOR2XL $PINS A=n6688 B=flag[0] Y=n4340
XU4190 NAND2XL $PINS A=flag[0] B=n6695 Y=n4341
XU4191 INVXL $PINS A=FE_OFN5576_register_7__19 Y=n5838
XU4192 INVXL $PINS A=n5818 Y=n5815
XU4193 NOR2X2 $PINS A=n6660 B=n5784 Y=n5263
XU4194 NAND2BX4 $PINS AN=N1700 B=n4941 Y=n5812
XU4195 XOR2X1 $PINS A=N1692 B=N1691 Y=N1728
XU4208 NAND2BXL $PINS AN=n5801 B=N1704 Y=n5799
XU4209 INVXL $PINS A=n5795 Y=n5793
XU4213 OR2X4 $PINS A=FE_OFN5677_n5350 B=FE_OFN93_n4441 Y=n5329
XU4214 INVX1 $PINS A=n4523 Y=n6699
XU4220 NOR2X1 $PINS A=n6708 B=n4444 Y=n4523
XU4221 INVX4 $PINS A=FE_RN_9 Y=n6630
XU4222 INVX1 $PINS A=n4444 Y=n6698
XU4226 OR2X4 $PINS A=n5916 B=n6690 Y=n5265
XU4227 OR2X4 $PINS A=n5915 B=n6690 Y=n5266
XU4231 OR2X4 $PINS A=FE_OFN5658_n5505 B=n6690 Y=n5332
XU4232 OR2X4 $PINS A=FE_OFN5658_n5505 B=n6690 Y=n5509
XU4233 OR2X4 $PINS A=FE_OFN176_n5348 B=n5566 Y=n5335
XU4234 OR2X4 $PINS A=FE_OFN176_n5348 B=FE_OFN93_n4441 Y=n5637
XU4236 OR2X2 $PINS A=FE_OFN5646_n5531 B=n6690 Y=n5326
XU4238 OR2X2 $PINS A=FE_OFN5646_n5531 B=n6690 Y=n5327
XU4239 OR2X2 $PINS A=FE_OFN5646_n5531 B=n6690 Y=n5533
XU4248 INVX1 $PINS A=n4395 Y=n6647
XU4249 AOI21X1 $PINS A0=n4410 A1=n6642 B0=n6698 Y=n4655
XU4250 INVX1 $PINS A=n4398 Y=n6642
XU4251 INVX1 $PINS A=n4811 Y=n6714
XU4253 INVX1 $PINS A=n4553 Y=n6671
XU4254 INVX1 $PINS A=n4558 Y=n6670
XU4256 INVX1 $PINS A=n4635 Y=n6652
XU4260 INVX1 $PINS A=n4364 Y=n6689
XU4261 INVX1 $PINS A=n4357 Y=n6619
XU4262 AOI21X1 $PINS A0=n5679 A1=n4363 B0=FE_OFN5704_n4378 Y=n4355
XU4266 OAI21XL $PINS A0=n6707 A1=n6709 B0=n6644 Y=n4793
XU4270 NOR2X1 $PINS A=n5916 B=n5835 Y=n5267
XU4271 NOR2X1 $PINS A=n5915 B=n5835 Y=n5268
XU4278 NAND2X1 $PINS A=n5679 B=FE_OFN599_n4378 Y=n4356
XU4281 OAI21X2 $PINS A0=n4415 A1=n6710 B0=n4407 Y=n5531
XU4282 AOI21X1 $PINS A0=FE_OCPN2332_FE_OFN5639_FE_RN_194_0 A1=n4414
+ B0=FE_OFN6148_n5006 Y=n4415
XU4283 INVX1 $PINS A=n4371 Y=n6709
XU4286 INVX1 $PINS A=n4754 Y=n5681
XU4287 OAI21XL $PINS A0=n4374 A1=n6710 B0=n4375 Y=n4363
XU4290 INVX1 $PINS A=n4582 Y=n6678
XU4291 INVX1 $PINS A=n4316 Y=n5679
XU4292 INVX1 $PINS A=n4596 Y=n6680
XU4293 INVX1 $PINS A=n4580 Y=n6675
XU4294 INVX1 $PINS A=n4579 Y=n6676
XU4295 INVX1 $PINS A=n4630 Y=n6681
XU4296 INVX1 $PINS A=n4301 Y=n6687
XU4298 XOR2X1 $PINS A=FE_OFN5546_register_3__16 B=n5283 Y=N630
XU4299 NAND4BX4 $PINS AN=n5270 B=FE_OFN5835_N1281 C=n5537
+ D=FE_DBTN78_register_5_3 Y=n5562
XU4300 NAND2X2 $PINS A=N1282 B=n5534 Y=n5270
XU4301 NAND3X1 $PINS A=n6713 B=n6697 C=n4354 Y=n4374
XU4302 NOR2X1 $PINS A=FE_DBTN1162_register_3_19 B=n5101 Y=n4811
XU4304 AOI31X2 $PINS A0=n6632 A1=n6674 A2=FE_OFN5608_a_cnt_7 B0=n6636 Y=n4584
XU4309 NAND2X2 $PINS A=n4601 B=n4600 Y=n1742
XU4311 INVX1 $PINS A=n4602 Y=n6692
XU4312 AOI22X1 $PINS A0=n6647 A1=n6699 B0=n4444 B1=n4635 Y=n4633
XU4314 OAI21XL $PINS A0=n4637 A1=n4410 B0=n4395 Y=n4636
XU4315 NOR2X1 $PINS A=n6719 B=N425 Y=n4390
XU4316 NOR2X1 $PINS A=n6718 B=n6706 Y=n4389
XU4317 NOR2X1 $PINS A=n4342 B=flag[2] Y=n4245
XU4319 INVX1 $PINS A=n4486 Y=n6701
XU4322 OAI21X4 $PINS A0=n4788 A1=n4787 B0=n5679 Y=n5835
XU4323 NAND2X1 $PINS A=n4305 B=n6693 Y=n4316
XU4324 OAI221XL $PINS A0=n5288 A1=n4395 B0=n6652 B1=n4396 C0=n4397 Y=n4393
XU4325 OAI222X1 $PINS A0=n4371 A1=n6618 B0=n4356 B1=n4372 C0=n4373 C1=n6718
+ Y=n1946
XU4326 OAI21XL $PINS A0=n6640 A1=n4363 B0=n6706 Y=n4372
XU4327 NAND2X1 $PINS A=n4792 B=N425 Y=n4396
XU4328 INVX4 $PINS A=n4688 Y=n5833
XU4329 NAND2BX2 $PINS AN=n4719 B=FE_OFN6148_n5006 Y=n4688
XU4330 AOI221X1 $PINS A0=N14688 A1=n4387 B0=n4384 B1=N14687 C0=n6709 Y=n4719
XU4331 INVX1 $PINS A=N425 Y=n6711
XU4333 OR2X2 $PINS A=n4368 B=n6706 Y=n4367
XU4334 NOR2X2 $PINS A=n4379 B=FE_OFN5704_n4378 Y=n4370
XU4335 AOI22X1 $PINS A0=n4641 A1=n4384 B0=n6711 B1=n6718 Y=n4639
XU4336 NAND2BX1 $PINS AN=n4371 B=N14585 Y=n5872
XU4338 OAI222XL $PINS A0=FE_OFN5986_n5003 A1=n5071 B0=FE_OCPN6244_n5352
+ B1=FE_DBTN1175_register_2_19 C0=FE_OFN5983_n5231 C1=n5059 Y=n1925
XU4339 OAI222XL $PINS A0=FE_OFN5986_n5003 A1=n5099 B0=FE_OFN6107_n5352 B1=n5214
+ C0=FE_OFN5983_n5231 C1=FE_OFN228_i_idata_2 Y=n1927
XU4340 OAI222X1 $PINS A0=FE_OFN5986_n5003 A1=n5067 B0=FE_OCPN6244_n5352
+ B1=FE_OFN5805_register_2__17 C0=FE_OFN5983_n5231 C1=n5055 Y=n1942
XU4341 OAI222X4 $PINS A0=FE_OFN5986_n5003 A1=n5097 B0=FE_OFN6107_n5352
+ B1=FE_DBTN1181_register_2_1 C0=FE_OFN5983_n5231 C1=n5023 Y=n1926
XU4342 OAI222XL $PINS A0=FE_OFN5986_n5003 A1=n5073 B0=FE_OCPN6245_n5352
+ B1=FE_OFN5883_N567 C0=FE_OFN5983_n5231 C1=n5021 Y=n1944
XU4343 OAI222X1 $PINS A0=FE_OFN5986_n5003 A1=n5063 B0=FE_OFN6107_n5352
+ B1=FE_DBTN116_register_2_5 C0=FE_OFN5983_n5231 C1=n5031 Y=n1930
XU4344 OAI222X4 $PINS A0=FE_OFN5986_n5003 A1=n5077 B0=FE_OFN6107_n5352
+ B1=FE_OFN5788_register_2__6 C0=FE_OFN5983_n5231 C1=n5033 Y=n1931
XU4345 OAI222XL $PINS A0=n5097 A1=n5326 B0=n5023 B1=n5328 C0=N1282
+ C1=FE_OFN6058_n5531 Y=n1906
XU4346 OAI222XL $PINS A0=n5061 A1=n5327 B0=n5029 B1=n5328 C0=n5534
+ C1=FE_OFN6058_n5531 Y=n1909
XU4347 OAI222XL $PINS A0=FE_OFN205_i_cdata_rd_3 A1=n5326 B0=n5027 B1=n5328
+ C0=FE_DBTN78_register_5_3 C1=FE_OFN6058_n5531 Y=n1908
XU4348 OAI222XL $PINS A0=n5225 A1=FE_OFN5602_n4937 B0=FE_OFN5956_n5349
+ B1=FE_DBTN32_N607 C0=FE_OFN6126_n5229 C1=FE_OFN205_i_cdata_rd_3 Y=n1831
XU4349 OAI222XL $PINS A0=FE_OFN5986_n5003 A1=n5087 B0=FE_OFN6107_n5352
+ B1=FE_DBTN122_register_2_12 C0=FE_OFN5983_n5231 C1=n5045 Y=n1937
XU4350 OAI222XL $PINS A0=n5225 A1=FE_DBTN94_register_4_8 B0=FE_OFN5956_n5349
+ B1=FE_OFN354_N612 C0=FE_OFN6126_n5229 C1=n5081 Y=n1841
XU4351 OAI222XL $PINS A0=FE_OFN5986_n5003 A1=n5093 B0=FE_OFN6107_n5352
+ B1=FE_OFN271_register_2__15 C0=FE_OFN5983_n5231 C1=n5051 Y=n1940
XU4352 OAI222X1 $PINS A0=FE_OFN5986_n5003 A1=n5081 B0=FE_OFN6107_n5352
+ B1=FE_OFN5755_register_2__8 C0=FE_OFN5983_n5231 C1=FE_OFN200_i_idata_8 Y=n1933
XU4353 OAI222X1 $PINS A0=FE_OFN5986_n5003 A1=n5085 B0=FE_OFN6107_n5352
+ B1=FE_DBTN121_register_2_11 C0=FE_OFN5983_n5231 C1=n5043 Y=n1936
XU4354 OAI222X1 $PINS A0=FE_OFN5986_n5003 A1=n5089 B0=FE_OFN6107_n5352
+ B1=FE_DBTN1157_register_2_13 C0=FE_OFN5983_n5231 C1=n5047 Y=n1938
XU4355 OAI222XL $PINS A0=n5081 A1=n5509 B0=FE_DBTN132_register_1_8 B1=n5507
+ C0=FE_OFN5862_register_0__8 C1=n5435 Y=n1873
XU4356 OAI222XL $PINS A0=FE_OFN5986_n5003 A1=n5061 B0=FE_OFN6107_n5352
+ B1=FE_DBTN1155_register_2_4 C0=FE_OFN5983_n5231 C1=n5029 Y=n1929
XU4357 OAI222XL $PINS A0=n5073 A1=n5509 B0=FE_DBTN9_N1143 B1=n5334
+ C0=FE_OFN5668_N1618 C1=n5435 Y=n1865
XU4358 OAI222XL $PINS A0=n5225 A1=FE_OFN5553_register_4__11 B0=FE_OFN5956_n5349
+ B1=FE_DBTN1184_register_3_11 C0=FE_OFN6126_n5229 C1=n5085 Y=n1847
XU4359 OAI222X1 $PINS A0=FE_OFN5986_n5003 A1=n5065 B0=FE_OFN6107_n5352
+ B1=FE_OFN5781_register_2__10 C0=FE_OFN5983_n5231 C1=n5041 Y=n1935
XU4360 OAI222XL $PINS A0=FE_OFN5986_n5003 A1=n5095 B0=FE_OCPN6244_n5352
+ B1=FE_DBTN126_register_2_16 C0=FE_OFN5983_n5231 C1=n5053 Y=n1941
XU4361 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=FE_OFN5855_FE_DBTN21_N1711
+ B0=FE_OFN5655_n6755 B1=N1455 C0=FE_OCPN6260_n5230 C1=n5073 Y=n1762
XU4363 OAI222X4 $PINS A0=FE_OFN5986_n5003 A1=n5083 B0=FE_OFN6107_n5352
+ B1=FE_OFN602_register_2__9 C0=FE_OFN5983_n5231 C1=n5039 Y=n1934
XU4364 OAI222XL $PINS A0=FE_OFN5986_n5003 A1=n5079 B0=FE_OFN6107_n5352
+ B1=FE_DBTN118_register_2_7 C0=FE_OFN5983_n5231 C1=n5035 Y=n1932
XU4365 OAI222XL $PINS A0=n5089 A1=n5332 B0=n5490 B1=n5507
+ C0=FE_OFN5790_register_0__13 C1=n5435 Y=n1878
XU4366 OAI222XL $PINS A0=FE_OFN5956_n5349 A1=FE_OFN5547_register_3__14 B0=n5225
+ B1=FE_OFN79_register_4__14 C0=FE_OFN6126_n5229 C1=n5091 Y=n1853
XU4367 OAI222XL $PINS A0=n5225 A1=FE_DBTN1173_register_4_7 B0=FE_OFN5956_n5349
+ B1=FE_OFN89_N611 C0=FE_OFN6126_n5229 C1=n5079 Y=n1839
XU4368 OAI222XL $PINS A0=FE_OFN5986_n5003 A1=n5069 B0=FE_OCPN6245_n5352
+ B1=FE_OFN5870_register_2__18 C0=FE_OFN5983_n5231 C1=n5057 Y=n1943
XU4369 OAI222XL $PINS A0=FE_OFN5956_n5349 A1=FE_DBTN112_register_3_18 B0=n5225
+ B1=FE_OFN5703_register_4__18 C0=FE_OFN6126_n5229 C1=n5069 Y=n1861
XU4370 OAI222XL $PINS A0=FE_OFN5956_n5349 A1=FE_OFN5919_N608 B0=n5225
+ B1=FE_DBTN90_register_4_4 C0=FE_OFN6126_n5229 C1=n5061 Y=n1833
XU4371 OAI222XL $PINS A0=FE_OFN5956_n5349 A1=n5101 B0=n5225
+ B1=FE_OFN5839_register_4__9 C0=FE_OFN6126_n5229 C1=n5083 Y=n1843
XU4372 OAI222XL $PINS A0=FE_OFN5956_n5349 A1=FE_DBTN29_N610 B0=n5225
+ B1=FE_DBTN1174_register_4_6 C0=FE_OFN6126_n5229 C1=n5077 Y=n1837
XU4373 OAI222XL $PINS A0=n5227 A1=FE_OFN5577_register_7__16 B0=FE_OFN5655_n6755
+ B1=FE_DBTN74_register_6_16 C0=n5230 C1=n5095 Y=n1810
XU4374 OAI222X1 $PINS A0=FE_OFN5986_n5003 A1=n5091 B0=FE_OFN6107_n5352
+ B1=FE_OFN5534_register_2__14 C0=FE_OFN5983_n5231 C1=n5049 Y=n1939
XU4375 OAI222XL $PINS A0=n5071 A1=n5327 B0=n5059 B1=n5328
+ C0=FE_DBTN89_register_5_19 C1=FE_OFN6057_n5531 Y=n1905
XU4376 OAI222XL $PINS A0=n5093 A1=n5326 B0=n5051 B1=n5328
+ C0=FE_DBTN85_register_5_15 C1=FE_OFN6057_n5531 Y=n1920
XU4377 OAI222XL $PINS A0=n5083 A1=n5326 B0=n5039 B1=n5328
+ C0=FE_OFN329_register_5__9 C1=FE_OFN6057_n5531 Y=n1914
XU4378 OAI222XL $PINS A0=n5087 A1=n5533 B0=n5045 B1=n5328
+ C0=FE_DBTN82_register_5_12 C1=FE_OFN6057_n5531 Y=n1917
XU4379 OAI222XL $PINS A0=n5067 A1=n5533 B0=n5055 B1=n5328
+ C0=FE_DBTN87_register_5_17 C1=FE_OFN6057_n5531 Y=n1922
XU4380 OAI222XL $PINS A0=n5065 A1=n5327 B0=n5041 B1=n5328
+ C0=FE_DBTN81_register_5_10 C1=FE_OFN6057_n5531 Y=n1915
XU4381 OAI222XL $PINS A0=n5089 A1=n5327 B0=n5047 B1=n5328
+ C0=FE_DBTN83_register_5_13 C1=FE_OFN6057_n5531 Y=n1918
XU4382 OAI222XL $PINS A0=n5091 A1=n5326 B0=n5049 B1=n5328
+ C0=FE_DBTN84_register_5_14 C1=FE_OFN6057_n5531 Y=n1919
XU4383 OAI222XL $PINS A0=n5095 A1=n5327 B0=n5053 B1=n5328
+ C0=FE_DBTN86_register_5_16 C1=FE_OFN6057_n5531 Y=n1921
XU4384 OAI222XL $PINS A0=n5069 A1=n5326 B0=n5057 B1=n5328
+ C0=FE_DBTN88_register_5_18 C1=FE_OFN6057_n5531 Y=n1923
XU4385 OAI222XL $PINS A0=n5095 A1=n5332 B0=n5715 B1=n5334
+ C0=FE_DBTN146_register_0_16 C1=FE_OCPN6250_n5505 Y=n1881
XU4386 OAI222XL $PINS A0=n5079 A1=n5327 B0=n5035 B1=n5328
+ C0=FE_OFN400_register_5__7 C1=FE_OFN5647_n5531 Y=n1912
XU4387 OAI222XL $PINS A0=n5063 A1=n5533 B0=n5031 B1=n5328
+ C0=FE_DBTN79_register_5_5 C1=FE_OFN6058_n5531 Y=n1910
XU4388 OAI222XL $PINS A0=n5077 A1=n5326 B0=n5033 B1=n5328 C0=n5418
+ C1=FE_OFN6057_n5531 Y=n1911
XU4389 OAI222XL $PINS A0=n5081 A1=n5533 B0=FE_OFN200_i_idata_8 B1=n5328
+ C0=FE_OFN5932_register_5__8 C1=FE_OFN6057_n5531 Y=n1913
XU4390 OAI222XL $PINS A0=n5093 A1=n5332 B0=n5436 B1=n5507 C0=n6773 C1=n5435
+ Y=n1880
XU4391 OAI222XL $PINS A0=n5083 A1=n5332 B0=n5494 B1=n5334
+ C0=FE_OFN5895_register_0__9 C1=n5435 Y=n1874
XU4392 OAI222XL $PINS A0=n5079 A1=n5332 B0=n5496 B1=n5507
+ C0=FE_OFN5877_register_0__7 C1=n5435 Y=n1872
XU4393 OAI222XL $PINS A0=n5087 A1=n5509 B0=FE_DBTN134_register_1_12 B1=n5334
+ C0=FE_OFN5518_register_0__12 C1=n5435 Y=n1877
XU4394 OAI222XL $PINS A0=n5225 A1=FE_OFN5551_register_4__16 B0=FE_OFN5956_n5349
+ B1=FE_OFN75_register_3__16 C0=FE_OFN6126_n5229 C1=n5095 Y=n1857
XU4395 OAI21XL $PINS A0=n4389 A1=n6644 B0=n4390 Y=n4381
XU4396 NAND2X1 $PINS A=n4755 B=n6718 Y=n4371
XU4397 INVX1 $PINS A=n4362 Y=n6702
XU4398 AOI211X1 $PINS A0=n6719 A1=n6706 B0=n4361 C0=n6640 Y=n4359
XU4399 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5035 B0=FE_OFN5957_n5634
+ B1=FE_DBTN39_register_8_7 Y=n1785
XU4400 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5059 B0=FE_OFN5957_n5634
+ B1=FE_DBTN1176_register_8_19 Y=n1821
XU4401 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=FE_OFN200_i_idata_8
+ B0=FE_OFN5957_n5634 B1=FE_OFN5732_register_8__8 Y=n1788
XU4402 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5051 B0=FE_OFN5957_n5634
+ B1=FE_OFN5709_register_8__15 Y=n1809
XU4403 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5041 B0=FE_OFN5957_n5634
+ B1=FE_DBTN1172_register_8_10 Y=n1794
XU4404 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5039 B0=FE_OFN5957_n5634
+ B1=FE_OFN5586_register_8__9 Y=n1791
XU4405 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5043 B0=FE_OFN5957_n5634
+ B1=FE_DBTN43_register_8_11 Y=n1797
XU4406 OAI22X1 $PINS A0=n5021 A1=FE_OFN5967_n4998 B0=FE_DBTN8_N1034
+ B1=FE_OFN5957_n5634 Y=n1764
XU4407 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5057 B0=FE_OFN5957_n5634
+ B1=FE_DBTN1161_register_8_18 Y=n1818
XU4408 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5053 B0=FE_OFN5957_n5634
+ B1=FE_OFN306_register_8__16 Y=n1812
XU4409 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5055 B0=FE_OFN5957_n5634
+ B1=FE_DBTN49_register_8_17 Y=n1815
XU4410 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5047 B0=FE_OFN5957_n5634
+ B1=FE_DBTN45_register_8_13 Y=n1803
XU4411 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5049 B0=FE_OFN5957_n5634
+ B1=FE_OFN304_register_8__14 Y=n1806
XU4412 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5033 B0=FE_OFN5957_n5634
+ B1=FE_DBTN38_register_8_6 Y=n1782
XU4414 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5045 B0=FE_OFN5957_n5634
+ B1=FE_OFN605_register_8__12 Y=n1800
XU4415 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5031 B0=FE_OFN5957_n5634
+ B1=FE_OFN5719_register_8__5 Y=n1779
XU4416 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=n5027 B0=FE_OFN5957_n5634
+ B1=FE_DBTN1169_register_8_3 Y=n1773
XU4417 OAI22X1 $PINS A0=FE_OFN5967_n4998 A1=FE_OFN228_i_idata_2
+ B0=FE_OFN5957_n5634 B1=FE_DBTN34_register_8_2 Y=n1770
XU4418 OAI22X1 $PINS A0=n6693 A1=FE_OFN5807_n4337 B0=n6623 B1=n4338 Y=n1998
XU4419 AOI211X1 $PINS A0=n4339 A1=n6648 B0=n5679 C0=n4340 Y=n4338
XU4420 NOR2X1 $PINS A=n4335 B=n6688 Y=n4317
XU4422 OAI21X1 $PINS A0=n4409 A1=FE_OCPN6188_n6646 B0=n5260 Y=n4408
XU4424 OAI21XL $PINS A0=n6623 A1=n6690 B0=n4336 Y=n1999
XU4425 OAI21XL $PINS A0=n6623 A1=n6695 B0=flag[2] Y=n4336
XU4426 AOI211X1 $PINS A0=n4479 A1=n6647 B0=n4480 C0=n4481 Y=n4477
XU4427 NOR3X1 $PINS A=n6698 B=n4443 C=n4482 Y=n4480
XU4429 OAI2BB1X2 $PINS A0N=n4479 A1N=n5006 B0=n4449 Y=n5505
XU4431 NAND2BX2 $PINS AN=n4791 B=FE_OFN6148_n5006 Y=n4756
XU4432 AOI221X1 $PINS A0=N14519 A1=n6707 B0=N14546 B1=n6708 C0=n5260 Y=n4791
XU4434 OAI222XL $PINS A0=n5225 A1=FE_DBTN13_N1253 B0=FE_OFN5956_n5349
+ B1=FE_DBTN11_N1177 C0=FE_OFN6126_n5229 C1=n5097 Y=n1863
XU4435 OAI222XL $PINS A0=n5073 A1=n5327 B0=n5021 B1=n5328 C0=FE_OFN5835_N1281
+ C1=FE_OFN6058_n5531 Y=n1924
XU4436 INVX1 $PINS A=n4402 Y=n6640
XU4438 NOR2X1 $PINS A=FE_RN_38_0 B=n4599 Y=n4582
XU4439 NOR2X1 $PINS A=n6681 B=FE_RN_38_0 Y=n4596
XU4440 INVX1 $PINS A=flag[2] Y=n6688
XU4441 NAND3X1 $PINS A=FE_RN_64_0 B=n6679 C=n4606 Y=n4619
XU4442 NOR2X1 $PINS A=n4620 B=FE_RN_244_0 Y=n4630
XU4443 NAND2X1 $PINS A=n4587 B=FE_RN_38_0 Y=n4579
XU4444 NAND2X1 $PINS A=n4587 B=n6678 Y=n4571
XU4445 NAND2X1 $PINS A=n4587 B=n6680 Y=n4570
XU4446 NAND2X1 $PINS A=n4587 B=n4588 Y=n4580
XU4447 NAND2X1 $PINS A=n4569 B=n6675 Y=n4558
XU4448 NAND2BX1 $PINS AN=n4570 B=n4569 Y=n4551
XU4449 NAND2BX1 $PINS AN=n4571 B=n4569 Y=n4554
XU4450 NAND2X1 $PINS A=n6676 B=n4569 Y=n4553
XU4451 OR3XL $PINS A=n4562 B=n6673 C=n6669 Y=n4557
XU4452 INVX1 $PINS A=n4342 Y=n6648
XU4453 NOR2X1 $PINS A=n4341 B=n6688 Y=n4302
XU4454 AOI2BB2X1 $PINS A0N=n4396 A1N=FE_OFN75_register_3__16
+ B0=FE_OFN5532_register_2__16 B1=n6707 Y=n5717
XU4455 OR3XL $PINS A=n4561 B=n6673 C=n6669 Y=n4555
XU4456 OR2X2 $PINS A=n4341 B=FE_OCPN1114_n4350 Y=n4346
XU4458 INVX1 $PINS A=n4588 Y=n6682
XU4471 AOI2BB1XL $PINS A0N=FE_DBTN1171_register_3_12 A1N=n5519 B0=n5108 Y=n5515
XU4472 AND3X1 $PINS A=FE_OFN5813_register_3__18 B=FE_OFN6008_register_3__19
+ C=n5282 Y=N634
XU4473 INVX1 $PINS A=n5826 Y=n2274
XU4474 INVX1 $PINS A=n5827 Y=n4878
XU4475 INVX1 $PINS A=n5829 Y=n4880
XU4476 INVX1 $PINS A=n5828 Y=n4879
XU4477 INVX1 $PINS A=n5830 Y=n4881
XU4478 MXI2X1 $PINS S0=n6654 B=n5523 A=n5524 Y=N620
XU4479 XOR2X1 $PINS A=FE_DBTN29_N610 B=FE_OFN5546_register_3__16 Y=n5523
XU4480 INVXL $PINS A=n4819 Y=n5522
XU4481 MXI2X1 $PINS S0=n6655 B=n5527 A=n5528 Y=N617
XU4482 XOR2XL $PINS A=FE_DBTN32_N607 B=n5108 Y=n5527
XU4483 INVXL $PINS A=n4830 Y=n5526
XU4491 OAI21XL $PINS A0=n6654 A1=n4822 B0=n4819 Y=n4820
XU4492 OAI21XL $PINS A0=n6655 A1=n4833 B0=n4830 Y=n4831
XU4499 NAND2X1 $PINS A=n5885 B=n5884 Y=n1701
XU4500 NAND2X2 $PINS A=n5887 B=n5886 Y=n1700
XU4501 NAND2X1 $PINS A=n5823 B=n5822 Y=n1723
XU4502 NAND2X1 $PINS A=n5889 B=n5888 Y=n1699
XU4503 NAND2X1 $PINS A=n5883 B=n5882 Y=n1702
XU4504 NAND2X1 $PINS A=n5724 B=n5723 Y=n1666
XU4505 NAND2X1 $PINS A=n5726 B=n5725 Y=n1665
XU4508 INVX1 $PINS A=n5831 Y=n4882
XU4509 INVX1 $PINS A=n5687 Y=n4871
XU4510 INVX1 $PINS A=n5832 Y=n4883
XU4511 INVX1 $PINS A=n5688 Y=n4872
XU4512 INVX1 $PINS A=n5689 Y=n4873
XU4513 NOR3X1 $PINS A=n3634 B=r_cnt[3] C=n6712 Y=n4400
XU4517 NAND2X1 $PINS A=n5891 B=n5890 Y=n1698
XU4518 NAND2X1 $PINS A=n5895 B=n5894 Y=n1696
XU4519 NAND2X1 $PINS A=n5893 B=n5892 Y=n1697
XU4522 NAND2X1 $PINS A=n5727 B=n5728 Y=n1664
XU4525 NAND2X2 $PINS A=n5734 B=n5733 Y=n1661
XU4526 NAND2X1 $PINS A=n5730 B=n5729 Y=n1663
XU4528 OAI21X1 $PINS A0=n4544 A1=n4543 B0=n6668 Y=n4545
XU4529 NAND2X2 $PINS A=n5736 B=n5735 Y=n1660
XU4530 NAND2X1 $PINS A=n5731 B=n5732 Y=n1662
XU4531 OR3XL $PINS A=n6705 B=r_cnt[1] C=n6711 Y=n5287
XU4532 OAI222XL $PINS A0=n3634 A1=n4365 B0=n4366 B1=n4356 C0=n4367 C1=n6618
+ Y=n1947
XU4534 NAND2X2 $PINS A=n5905 B=FE_OCPN2337_n5904 Y=n1691
XU4535 NAND2X2 $PINS A=FE_OCPN6253_n5897 B=n5896 Y=n1695
XU4536 NAND2X1 $PINS A=n5907 B=n5906 Y=n1690
XU4537 NAND2X2 $PINS A=n5901 B=n5900 Y=n1693
XU4538 NAND2X1 $PINS A=n5737 B=n5738 Y=n1659
XU4539 NAND2X2 $PINS A=n5899 B=n5898 Y=n1694
XU4540 NAND2X2 $PINS A=n5740 B=n5739 Y=n1658
XU4541 NAND2X1 $PINS A=n5741 B=n5742 Y=n1657
XU4542 NAND2X1 $PINS A=n5749 B=n5750 Y=n1653
XU4543 NAND2X1 $PINS A=n5743 B=n5744 Y=n1656
XU4544 NAND2X1 $PINS A=n5909 B=n5908 Y=n1689
XU4545 NAND2X1 $PINS A=n5746 B=n5745 Y=n1655
XU4546 NAND2X1 $PINS A=n5748 B=n5747 Y=n1654
XU4547 AOI222X1 $PINS A0=n5216 A1=FE_OFN6151_n5224 B0=FE_OFN5622_CMF0_2
+ B1=FE_OCPN6248_FE_DBTN1185_n4720 C0=FE_OCPN6193_n5223 C1=FE_OFN5588_N606
+ Y=n5747
XU4549 NAND2X1 $PINS A=n5753 B=n5752 Y=n1688
XU4551 NAND2X1 $PINS A=n4262 B=n4263 Y=n3669
XU4552 OAI222XL $PINS A0=n5063 A1=n5332 B0=FE_DBTN131_register_1_5 B1=n5507
+ C0=n5761 C1=n5435 Y=n1870
XU4553 OAI222XL $PINS A0=n5065 A1=n5509 B0=FE_DBTN133_register_1_10 B1=n5507
+ C0=n5765 C1=n5435 Y=n1875
XU4554 OAI222XL $PINS A0=n5061 A1=n5509 B0=n5500 B1=n5507 C0=n5760 C1=n5435
+ Y=n1869
XU4555 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=n4945 B0=FE_OFN5655_n6755
+ B1=FE_OFN5574_register_6__4 C0=FE_OCPN6260_n5230 C1=n5061 Y=n1774
XU4557 OAI222XL $PINS A0=n5069 A1=n5332 B0=n5507 B1=n5104 C0=n5435
+ C1=FE_OFN5846_register_0__18 Y=n1883
XU4561 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=FE_DBTN53_register_7_3
+ B0=FE_OFN5655_n6755 B1=FE_DBTN1183_register_6_3 C0=FE_OCPN6260_n5230
+ C1=FE_OFN205_i_cdata_rd_3 Y=n1771
XU4563 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=FE_OFN5661_register_7__10
+ B0=FE_OFN5655_n6755 B1=FE_DBTN68_register_6_10 C0=FE_OCPN6260_n5230 C1=n5065
+ Y=n1792
XU4566 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=n5643 B0=FE_OFN5655_n6755
+ B1=FE_OFN390_register_6__7 C0=FE_OCPN6260_n5230 C1=n5079 Y=n1783
XU4567 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=FE_OFN5689_register_7__2
+ B0=FE_OFN5655_n6755 B1=FE_DBTN1158_n4963 C0=FE_OCPN6260_n5230 C1=n5099 Y=n1768
XU4568 OAI222XL $PINS A0=FE_OFN5655_n6755 A1=FE_DBTN69_register_6_11
+ B0=FE_OCPN6262_n5227 B1=n5655 C0=FE_OCPN6260_n5230 C1=n5085 Y=n1795
XU4569 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=n5644 B0=FE_OFN5655_n6755
+ B1=FE_OFN5570_register_6__8 C0=FE_OCPN6260_n5230 C1=n5081 Y=n1786
XU4571 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=FE_DBTN57_register_7_13
+ B0=FE_OFN5655_n6755 B1=FE_DBTN71_register_6_13 C0=FE_OCPN6260_n5230 C1=n5089
+ Y=n1801
XU4573 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=FE_DBTN56_register_7_12
+ B0=FE_OFN5655_n6755 B1=FE_DBTN70_register_6_12 C0=FE_OCPN6260_n5230 C1=n5087
+ Y=n1798
XU4575 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=FE_DBTN54_register_7_9
+ B0=FE_OFN5655_n6755 B1=FE_OFN616_register_6__9 C0=FE_OCPN6260_n5230 C1=n5083
+ Y=n1789
XU4577 OAI222XL $PINS A0=FE_OFN5655_n6755 A1=FE_OFN5567_register_6__18
+ B0=FE_OCPN6262_n5227 B1=FE_OFN5700_register_7__18 C0=FE_OCPN6260_n5230 C1=n5069
+ Y=n1816
XU4578 OAI222XL $PINS A0=FE_OFN5655_n6755 A1=FE_DBTN73_register_6_15
+ B0=FE_OCPN6262_n5227 B1=FE_DBTN59_register_7_15 C0=FE_OCPN6260_n5230 C1=n5093
+ Y=n1807
XU4580 OAI222XL $PINS A0=n5077 A1=n5509 B0=n5498 B1=n5334
+ C0=FE_OFN5914_register_0__6 C1=n5435 Y=n1871
XU4582 OAI222XL $PINS A0=FE_OFN5655_n6755 A1=FE_DBTN77_register_6_19
+ B0=FE_OCPN6262_n5227 B1=n5838 C0=FE_OCPN6260_n5230 C1=n5071 Y=n1819
XU4584 OAI222XL $PINS A0=FE_OFN5655_n6755 A1=FE_DBTN72_register_6_14 B0=n5227
+ B1=FE_DBTN58_register_7_14 C0=n5230 C1=n5091 Y=n1804
XU4586 OAI222XL $PINS A0=FE_OFN5655_n6755 A1=FE_DBTN75_register_6_17
+ B0=FE_OCPN6262_n5227 B1=n5861 C0=FE_OCPN6260_n5230 C1=n5067 Y=n1813
XU4588 OAI222XL $PINS A0=n5067 A1=n5509 B0=n5334 B1=FE_DBTN136_register_1_17
+ C0=n5435 C1=FE_OFN5863_register_0__17 Y=n1882
XU4589 OAI222XL $PINS A0=n5071 A1=n5509 B0=n5507 B1=n4988
+ C0=FE_OFN5735_register_0__19 C1=n5435 Y=n1884
XU4591 OAI222XL $PINS A0=FE_OFN5655_n6755 A1=FE_OFN5573_register_6__5
+ B0=FE_OCPN6262_n5227 B1=n5621 C0=FE_OCPN6260_n5230 C1=n5063 Y=n1777
XU4592 OAI222XL $PINS A0=n5091 A1=n5509 B0=FE_DBTN135_register_1_14 B1=n5507
+ C0=FE_DBTN145_register_0_14 C1=n5435 Y=n1879
XU4593 OAI21XL $PINS A0=flag[0] A1=n4317 B0=flag[1] Y=n4315
XU4594 OAI221XL $PINS A0=FE_OFN5950_n4451 A1=FE_OFN5839_register_4__9
+ B0=FE_OFN6171_n5232 B1=n5083 C0=n4467 Y=n1844
XU4595 AOI22XL $PINS A0=FE_OFN5995_n5018 A1=idata[9] B0=n5233
+ B1=FE_OFN5563_register_5__9 Y=n4467
XU4596 OAI221XL $PINS A0=FE_OFN5950_n4451 A1=FE_DBTN0_n6728 B0=FE_OFN6171_n5232
+ B1=n5067 C0=n4459 Y=n1860
XU4597 AOI22X1 $PINS A0=FE_OFN5995_n5018 A1=idata[17] B0=n5233
+ B1=register[5][17] Y=n4459
XU4598 OAI221XL $PINS A0=FE_OFN5950_n4451 A1=FE_OFN5712_register_4__15
+ B0=FE_OFN6171_n5232 B1=n5093 C0=n4461 Y=n1856
XU4599 AOI22XL $PINS A0=FE_OFN5995_n5018 A1=idata[15] B0=n5233
+ B1=FE_OFN5560_register_5__15 Y=n4461
XU4600 OAI221XL $PINS A0=FE_OFN5950_n4451 A1=FE_OFN5550_register_4__19
+ B0=FE_OFN6171_n5232 B1=n5071 C0=n4475 Y=n1828
XU4601 AOI22XL $PINS A0=FE_OFN5995_n5018 A1=idata[19] B0=n5233
+ B1=FE_OFN5558_register_5__19 Y=n4475
XU4602 OAI221XL $PINS A0=FE_OFN5950_n4451 A1=FE_OFN5551_register_4__16
+ B0=FE_OFN6171_n5232 B1=n5095 C0=n4460 Y=n1858
XU4603 AOI22XL $PINS A0=FE_OFN5995_n5018 A1=idata[16] B0=n5233
+ B1=FE_OFN5559_register_5__16 Y=n4460
XU4604 OAI221XL $PINS A0=FE_OFN5950_n4451 A1=FE_OFN309_register_4__13
+ B0=FE_OFN6171_n5232 B1=n5089 C0=n4463 Y=n1852
XU4605 AOI22X1 $PINS A0=FE_OFN5995_n5018 A1=idata[13] B0=n5233
+ B1=register[5][13] Y=n4463
XU4606 OAI221XL $PINS A0=FE_OFN5950_n4451 A1=FE_OFN5703_register_4__18
+ B0=FE_OFN6171_n5232 B1=n5069 C0=n4458 Y=n1862
XU4607 AOI22X1 $PINS A0=FE_OFN5995_n5018 A1=idata[18] B0=n5233
+ B1=register[5][18] Y=n4458
XU4608 OAI221XL $PINS A0=FE_OFN5950_n4451 A1=FE_OFN5553_register_4__11 B0=n5232
+ B1=n5085 C0=FE_OCPN6252_n4465 Y=n1848
XU4609 AOI22XL $PINS A0=FE_OFN5995_n5018 A1=idata[11] B0=n5233
+ B1=register[5][11] Y=n4465
XU4610 OAI221XL $PINS A0=FE_OFN5950_n4451 A1=FE_OFN79_register_4__14
+ B0=FE_OFN6171_n5232 B1=n5091 C0=n4462 Y=n1854
XU4611 AOI22XL $PINS A0=FE_OFN5995_n5018 A1=idata[14] B0=n5233
+ B1=register[5][14] Y=n4462
XU4612 OAI221XL $PINS A0=FE_OFN5950_n4451 A1=FE_DBTN98_register_4_12
+ B0=FE_OFN6171_n5232 B1=n5087 C0=n4464 Y=n1850
XU4613 AOI22XL $PINS A0=FE_OFN5995_n5018 A1=idata[12] B0=n5233
+ B1=FE_OFN5561_register_5__12 Y=n4464
XU4614 INVX1 $PINS A=n5682 Y=n5844
XU4615 OAI31X1 $PINS A0=n6719 A1=n5681 A2=n5680 B0=n5679 Y=n5682
XU4616 INVX1 $PINS A=n4360 Y=n5680
XU4617 OAI221XL $PINS A0=FE_OFN5950_n4451 A1=FE_OFN5554_register_4__10 B0=n5232
+ B1=n5065 C0=n4466 Y=n1846
XU4618 AOI22X1 $PINS A0=FE_OFN5995_n5018 A1=idata[10] B0=n5233
+ B1=FE_OFN5562_register_5__10 Y=n4466
XU4619 AOI2BB2X1 $PINS A0N=FE_OCPN6191_n5348 A1N=n5655 B0=n5226 B1=cdata_rd[11]
+ Y=n5601
XU4620 AOI2BB2X1 $PINS A0N=FE_OFN5960_n5348 A1N=FE_DBTN54_register_7_9
+ B0=cdata_rd[9] B1=n5226 Y=n5608
XU4621 AOI2BB2X1 $PINS A0N=FE_OCPN6191_n5348 A1N=n5642 B0=cdata_rd[6] B1=n5226
+ Y=n5617
XU4622 AOI2BB2X1 $PINS A0N=FE_OCPN6191_n5348 A1N=FE_DBTN53_register_7_3
+ B0=n5226 B1=cdata_rd[3] Y=n5627
XU4623 AOI2BB2X1 $PINS A0N=FE_OCPN6191_n5348 A1N=FE_OFN5689_register_7__2
+ B0=cdata_rd[2] B1=n5226 Y=n5630
XU4624 AOI2BB2X1 $PINS A0N=FE_OCPN6191_n5348 A1N=n5643 B0=n5226 B1=cdata_rd[7]
+ Y=n5614
XU4625 AOI2BB2X1 $PINS A0N=FE_OCPN6191_n5348 A1N=n5644 B0=n5226 B1=cdata_rd[8]
+ Y=n5611
XU4626 AOI2BB2X1 $PINS A0N=FE_OCPN6191_n5348 A1N=n4945 B0=cdata_rd[4] B1=n5226
+ Y=n5624
XU4627 AOI2BB2X1 $PINS A0N=FE_OCPN6191_n5348 A1N=FE_OFN5855_FE_DBTN21_N1711
+ B0=n5226 B1=cdata_rd[0] Y=n5638
XU4628 AOI2BB2XL $PINS A0N=n5925 A1N=n5104 B0=FE_OCPN6255_n5001 B1=cdata_rd[18]
+ Y=n5438
XU4629 AOI2BB2XL $PINS A0N=n5351 A1N=n5715 B0=n5001 B1=cdata_rd[16] Y=n5445
XU4630 AOI2BB2XL $PINS A0N=n5351 A1N=n5490 B0=FE_OCPN6255_n5001 B1=cdata_rd[13]
+ Y=n5449
XU4631 AOI2BB2XL $PINS A0N=n5351 A1N=FE_DBTN130_register_1_3 B0=n5001
+ B1=cdata_rd[3] Y=n5476
XU4632 AOI2BB2XL $PINS A0N=n5925 A1N=n5436 B0=n5001 B1=cdata_rd[15] Y=n5432
XU4633 AOI2BB2XL $PINS A0N=n5351 A1N=n5496 B0=FE_OCPN6255_n5001 B1=cdata_rd[7]
+ Y=n5466
XU4634 AOI2BB2XL $PINS A0N=n5351 A1N=n5494 B0=FE_OCPN6255_n5001 B1=cdata_rd[9]
+ Y=n5460
XU4635 AOI2BB2X1 $PINS A0N=FE_OCPN6251_n5232 A1N=n5063 B0=FE_OFN5995_n5018
+ B1=idata[5] Y=n5412
XU4636 AOI2BB2X1 $PINS A0N=FE_OFN5960_n5348 A1N=FE_OFN5700_register_7__18
+ B0=cdata_rd[18] B1=n5226 Y=n5572
XU4637 AOI2BB2X2 $PINS A0N=FE_OFN5960_n5348 A1N=n5861 B0=cdata_rd[17] B1=n5226
+ Y=n5577
XU4638 AOI2BB2X1 $PINS A0N=FE_OFN5960_n5348 A1N=n5838 B0=cdata_rd[19] B1=n5226
+ Y=n5569
XU4639 AOI2BB2X1 $PINS A0N=FE_OFN5960_n5348 A1N=FE_OFN5577_register_7__16
+ B0=n5226 B1=cdata_rd[16] Y=n5582
XU4640 AOI2BB2X1 $PINS A0N=FE_OCPN6191_n5348 A1N=n5621 B0=cdata_rd[5] B1=n5226
+ Y=n5620
XU4642 AOI2BB2X1 $PINS A0N=FE_OFN5960_n5348 A1N=FE_OFN5661_register_7__10
+ B0=n5226 B1=cdata_rd[10] Y=n5604
XU4643 AOI2BB2X1 $PINS A0N=FE_OFN5960_n5348 A1N=FE_DBTN56_register_7_12
+ B0=n5226 B1=cdata_rd[12] Y=n5596
XU4644 AOI2BB2X1 $PINS A0N=FE_OFN5960_n5348 A1N=FE_DBTN57_register_7_13
+ B0=n5226 B1=cdata_rd[13] Y=n5593
XU4645 AOI2BB2XL $PINS A0N=n5351 A1N=FE_DBTN133_register_1_10 B0=n5005
+ B1=cdata_rd[10] Y=n5458
XU4646 AOI2BB2X1 $PINS A0N=n5351 A1N=n5498 B0=n5005 B1=cdata_rd[6] Y=n5470
XU4647 AOI2BB2X1 $PINS A0N=n5925 A1N=FE_DBTN135_register_1_14 B0=n5005
+ B1=cdata_rd[14] Y=n5447
XU4648 AOI2BB2X1 $PINS A0N=n5351 A1N=n4988 B0=n5005 B1=cdata_rd[19] Y=n5437
XU4649 AOI2BB2XL $PINS A0N=n5925 A1N=FE_DBTN132_register_1_8 B0=n5005
+ B1=cdata_rd[8] Y=n5464
XU4650 AOI2BB2XL $PINS A0N=n5351 A1N=FE_DBTN134_register_1_12 B0=n5005
+ B1=cdata_rd[12] Y=n5453
XU4651 AOI2BB2XL $PINS A0N=n5351 A1N=FE_DBTN136_register_1_17 B0=n5005
+ B1=cdata_rd[17] Y=n5441
XU4652 AOI2BB2X1 $PINS A0N=FE_OCPN6251_n5232 A1N=n5061 B0=FE_OFN5995_n5018
+ B1=idata[4] Y=n5407
XU4653 AOI2BB2X1 $PINS A0N=FE_OCPN6251_n5232 A1N=n5073 B0=FE_OFN5995_n5018
+ B1=idata[0] Y=n5389
XU4654 AOI2BB2XL $PINS A0N=FE_OCPN6251_n5232 A1N=n5099 B0=FE_OFN5995_n5018
+ B1=idata[2] Y=n5397
XU4655 AOI2BB2X2 $PINS A0N=FE_OCPN6251_n5232 A1N=FE_OFN205_i_cdata_rd_3
+ B0=FE_OFN5995_n5018 B1=idata[3] Y=n5401
XU4656 AOI2BB2XL $PINS A0N=FE_OCPN6251_n5232 A1N=n5097 B0=FE_OFN5995_n5018
+ B1=idata[1] Y=n5385
XU4657 OAI221XL $PINS A0=n6623 A1=n4341 B0=n4342 B1=FE_RN_117_0 C0=n4343
+ Y=n1997
XU4658 OAI21XL $PINS A0=n6623 A1=n4340 B0=flag[1] Y=n4343
XU4659 NAND2X1 $PINS A=n4268 B=n4269 Y=n3666
XU4660 NAND2X1 $PINS A=n4264 B=n4265 Y=n3668
XU4661 NAND2X1 $PINS A=n4266 B=n4267 Y=n3667
XU4662 NAND2X1 $PINS A=n4272 B=n4273 Y=n3664
XU4663 NAND2X1 $PINS A=n4274 B=n4275 Y=n3663
XU4664 NAND2X1 $PINS A=n4270 B=n4271 Y=n3665
XU4665 NAND2X1 $PINS A=n4276 B=n4277 Y=n3662
XU4666 NAND2X1 $PINS A=n4280 B=n4281 Y=n3660
XU4667 NAND2X1 $PINS A=n4278 B=n4279 Y=n3661
XU4668 AOI2BB2XL $PINS A0N=FE_OFN5678_n5350 A1N=FE_DBTN9_N1143 B0=n5005
+ B1=cdata_rd[0] Y=n5484
XU4669 AOI2BB2XL $PINS A0N=FE_OFN5678_n5350 A1N=FE_DBTN131_register_1_5
+ B0=n5001 B1=cdata_rd[5] Y=n5472
XU4670 AOI2BB2XL $PINS A0N=n5351 A1N=n5500 B0=n5005 B1=cdata_rd[4] Y=n5474
XU4671 AOI2BB2X1 $PINS A0N=FE_OCPN6251_n5232 A1N=n5077 B0=FE_OFN5995_n5018
+ B1=idata[6] Y=n5419
XU4672 AOI2BB2X1 $PINS A0N=FE_OCPN6251_n5232 A1N=n5079 B0=FE_OFN5995_n5018
+ B1=idata[7] Y=n5423
XU4673 AOI2BB2X1 $PINS A0N=FE_OFN6171_n5232 A1N=n5081 B0=FE_OFN5995_n5018
+ B1=idata[8] Y=n5427
XU4674 OAI222XL $PINS A0=FE_OCPN6262_n5227 A1=n5642 B0=FE_OFN5655_n6755
+ B1=FE_DBTN64_register_6_6 C0=FE_OCPN6260_n5230 C1=n5077 Y=n1780
XU4676 OAI2BB1X1 $PINS A0N=caddr_wr[7] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4310
+ Y=n3642
XU4677 INVX1 $PINS A=n4244 Y=n6649
XU4678 AOI22XL $PINS A0=FE_DBTN1_n5754 A1=FE_DBTN1170_register_0_17
+ B0=FE_RN_399_0 B1=FE_OFN6030_register_1__17 Y=n4748
XU4679 INVX1 $PINS A=n4228 Y=n6613
XU4680 INVX1 $PINS A=n4225 Y=n6612
XU4681 AOI22XL $PINS A0=FE_DBTN1_n5754 A1=FE_DBTN1167_register_0_19
+ B0=FE_RN_399_0 B1=FE_OFN5519_register_1__19 Y=n4735
XU4682 OAI2BB1X1 $PINS A0N=caddr_wr[2] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4314
+ Y=n3635
XU4683 OAI2BB1X1 $PINS A0N=caddr_wr[3] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4306
+ Y=n3650
XU4684 INVX1 $PINS A=n4240 Y=n6610
XU4685 INVX1 $PINS A=n4243 Y=n6650
XU4686 INVX1 $PINS A=n4239 Y=n6609
XU4687 INVX1 $PINS A=n4232 Y=n6617
XU4688 INVX1 $PINS A=n4231 Y=n6616
XU4689 NAND2X1 $PINS A=n4296 B=n4297 Y=n3652
XU4690 AOI22X1 $PINS A0=CMF1[18] A1=FE_OFN5958_n5004 B0=cdata_wr[2]
+ B1=FE_OFN5663_n4999 Y=n4296
XU4691 AOI222X4 $PINS A0=CMF0[18] A1=n4256 B0=FE_OFN5622_CMF0_2 B1=n5354
+ C0=FE_OFN5630_CMF1_2 C1=n5239 Y=n4297
XU4692 NAND2X1 $PINS A=n4290 B=n4291 Y=n3655
XU4693 AOI22X1 $PINS A0=FE_OFN5958_n5004 A1=CMF1[21] B0=cdata_wr[5]
+ B1=FE_OFN5663_n4999 Y=n4290
XU4694 AOI222X4 $PINS A0=n4256 A1=CMF0[21] B0=FE_OFN5620_CMF0_5 B1=n5354
+ C0=CMF1[5] C1=n5239 Y=n4291
XU4695 NAND2X1 $PINS A=n4282 B=n4283 Y=n3659
XU4696 AOI22X1 $PINS A0=FE_OFN5958_n5004 A1=CMF1[25] B0=cdata_wr[9]
+ B1=FE_OFN5663_n4999 Y=n4282
XU4697 AOI222X4 $PINS A0=n4256 A1=CMF0[25] B0=FE_OFN5617_CMF0_9 B1=n5354
+ C0=CMF1[9] C1=n5239 Y=n4283
XU4698 NAND2X1 $PINS A=n4254 B=n4255 Y=n3672
XU4699 AOI22X1 $PINS A0=CMF1[16] A1=FE_OFN5958_n5004 B0=cdata_wr[0]
+ B1=FE_OFN5663_n4999 Y=n4254
XU4700 AOI222X1 $PINS A0=CMF0[16] A1=n4256 B0=CMF0[0] B1=n5354
+ C0=FE_OFN5631_CMF1_0 C1=n5239 Y=n4255
XU4701 NAND2X1 $PINS A=n4294 B=n4295 Y=n3653
XU4702 AOI22X1 $PINS A0=CMF1[19] A1=FE_OFN5958_n5004 B0=cdata_wr[3]
+ B1=FE_OFN5663_n4999 Y=n4294
XU4703 AOI222X4 $PINS A0=CMF0[19] A1=n4256 B0=FE_OFN5621_CMF0_3 B1=n5354
+ C0=CMF1[3] C1=n5239 Y=n4295
XU4704 NAND2X1 $PINS A=n4284 B=n4285 Y=n3658
XU4705 AOI22X1 $PINS A0=FE_OFN5958_n5004 A1=CMF1[24] B0=cdata_wr[8]
+ B1=FE_OFN5663_n4999 Y=n4284
XU4706 AOI222X4 $PINS A0=CMF0[24] A1=n4256 B0=FE_OFN6265_CMF0_8 B1=n5354
+ C0=CMF1[8] C1=n5239 Y=n4285
XU4707 NAND2X1 $PINS A=n4298 B=n4299 Y=n3651
XU4708 AOI22X1 $PINS A0=CMF1[17] A1=FE_OFN5958_n5004 B0=cdata_wr[1]
+ B1=FE_OFN5663_n4999 Y=n4298
XU4709 AOI222X4 $PINS A0=CMF0[17] A1=n4256 B0=CMF0[1] B1=n5354 C0=CMF1[1]
+ C1=n5239 Y=n4299
XU4710 NAND2X1 $PINS A=n4286 B=n4287 Y=n3657
XU4711 AOI22X1 $PINS A0=FE_OFN5958_n5004 A1=CMF1[23] B0=cdata_wr[7]
+ B1=FE_OFN5663_n4999 Y=n4286
XU4712 AOI222X4 $PINS A0=n4256 A1=CMF0[23] B0=CMF0[7] B1=n5354 C0=CMF1[7]
+ C1=n5239 Y=n4287
XU4713 NAND2X1 $PINS A=n4292 B=n4293 Y=n3654
XU4714 AOI22X1 $PINS A0=FE_OFN5958_n5004 A1=CMF1[20] B0=cdata_wr[4]
+ B1=FE_OFN5663_n4999 Y=n4292
XU4715 AOI222X4 $PINS A0=n4256 A1=CMF0[20] B0=CMF0[4] B1=n5354 C0=CMF1[4]
+ C1=n5239 Y=n4293
XU4716 NAND2X1 $PINS A=n4288 B=n4289 Y=n3656
XU4717 AOI22X1 $PINS A0=FE_OFN5958_n5004 A1=CMF1[22] B0=cdata_wr[6]
+ B1=FE_OFN5663_n4999 Y=n4288
XU4718 AOI222X4 $PINS A0=n4256 A1=CMF0[22] B0=CMF0[6] B1=n5354 C0=CMF1[6]
+ C1=n5239 Y=n4289
XU4719 OAI2BB1X1 $PINS A0N=caddr_wr[1] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4261
+ Y=n3670
XU4720 OAI2BB1X1 $PINS A0N=caddr_wr[8] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4311
+ Y=n3640
XU4721 OAI2BB1X1 $PINS A0N=caddr_wr[10] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4313
+ Y=n3636
XU4722 OAI2BB1X1 $PINS A0N=caddr_wr[9] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4312
+ Y=n3638
XU4723 OAI2BB1X1 $PINS A0N=caddr_wr[11] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4260
+ Y=n3671
XU4724 OAI2BB1X1 $PINS A0N=caddr_wr[0] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4251
+ Y=n3673
XU4725 OAI2BB1X1 $PINS A0N=caddr_wr[6] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4309
+ Y=n3644
XU4726 OAI2BB1X1 $PINS A0N=caddr_wr[4] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4307
+ Y=n3648
XU4727 OAI2BB1X1 $PINS A0N=caddr_wr[5] A1N=FE_OFN459_FE_DBTN5_n4999 B0=n4308
+ Y=n3646
XU4728 INVX1 $PINS A=n4229 Y=n6614
XU4729 INVX1 $PINS A=n4241 Y=n6611
XU4730 INVX1 $PINS A=n4242 Y=n6651
XU4731 INVX1 $PINS A=n4230 Y=n6615
XU4732 INVX1 $PINS A=n4238 Y=n6608
XU4735 NOR2X1 $PINS A=n4607 B=FE_OFN5596_N8546 Y=n4606
XU4736 OAI2BB2X1 $PINS A0N=csel[1] A1N=n4484 B0=n4484 B1=n4488 Y=n1822
XU4738 AOI2BB2XL $PINS A0N=n5287 A1N=n5861 B0=register[6][17] B1=n4384 Y=n5862
XU4739 OAI21XL $PINS A0=r_cnt[1] A1=n6706 B0=r_cnt[3] Y=n4491
XU4740 INVX1 $PINS A=FE_OFN5598_N8548 Y=n6679
XU4741 NOR2X1 $PINS A=FE_OFN5609_a_cnt_6 B=n4630 Y=n4588
XU4742 AOI2BB2XL $PINS A0N=n5287 A1N=n5838 B0=register[6][19] B1=n4384 Y=n5839
XU4743 NAND3X1 $PINS A=FE_OFN5608_a_cnt_7 B=FE_OFN5607_a_cnt_8 C=n4582 Y=n4562
XU4744 OAI221XL $PINS A0=FE_OCPN1114_n4350 A1=n4304 B0=flag[2] B1=n4346
+ C0=n4351 Y=n1949
XU4745 NAND3X1 $PINS A=FE_OFN5598_N8548 B=FE_OFN5597_N8547 C=n4611 Y=n4620
XU4746 AOI2BB2XL $PINS A0N=n5287 A1N=FE_OFN5700_register_7__18
+ B0=FE_DBTN76_register_6_18 B1=n4384 Y=n5852
XU4747 AND3X2 $PINS A=N8545 B=FE_OFN5594_N8543 C=FE_OFN5596_N8546 Y=n4611
XU4748 NOR2X1 $PINS A=n4619 B=FE_OFN5599_N8549 Y=n4599
XU4749 OAI2BB2X1 $PINS A0N=caddr_rd[6] A1N=FE_OFN5688_FE_RN_5 B0=FE_RN_38_0
+ B1=FE_OFN5688_FE_RN_5 Y=n3674
XU4750 AOI2BB2XL $PINS A0N=n5288 A1N=FE_DBTN74_register_6_16 B0=n5649 B1=n4387
+ Y=n5874
XU4751 OAI2BB2X1 $PINS A0N=caddr_rd[3] A1N=FE_OFN5688_FE_RN_5 B0=FE_RN_64_0
+ B1=FE_OFN5688_FE_RN_5 Y=n3677
XU4752 OAI2BB2X1 $PINS A0N=caddr_rd[8] A1N=FE_OFN5688_FE_RN_5 B0=n6674
+ B1=FE_OFN5688_FE_RN_5 Y=n3681
XU4753 OAI2BB2X1 $PINS A0N=caddr_rd[5] A1N=FE_OFN5688_FE_RN_5 B0=FE_RN_244_0
+ B1=FE_OFN5688_FE_RN_5 Y=n3675
XU4754 OAI2BB2X1 $PINS A0N=caddr_rd[4] A1N=FE_OFN5688_FE_RN_5 B0=n6679
+ B1=FE_OFN5688_FE_RN_5 Y=n3676
XU4755 OAI2BB2X1 $PINS A0N=caddr_rd[2] A1N=FE_OFN5688_FE_RN_5 B0=n6685
+ B1=FE_OFN5688_FE_RN_5 Y=n3678
XU4756 OAI2BB2X1 $PINS A0N=csel[2] A1N=n4484 B0=n4484 B1=n4487 Y=n1823
XU4757 OAI2BB2X1 $PINS A0N=csel[0] A1N=n4484 B0=n4484 B1=n4485 Y=n1824
XU4758 OR2X2 $PINS A=N8545 B=FE_OFN5594_N8543 Y=n4607
XU4759 OAI21XL $PINS A0=FE_OCPN2331_FE_RN_2 A1=FE_RN_27 B0=n4348 Y=n1983
XU4760 OAI21XL $PINS A0=FE_OCPN1114_n4350 A1=n4304 B0=crd Y=n4349
XU4761 XNOR2X1 $PINS A=N14832 B=n4334 Y=n2001
XU4764 INVX1 $PINS A=FE_OFN5606_a_cnt_9 Y=n6673
XU4767 NOR2X1 $PINS A=FE_OFN5607_a_cnt_8 B=FE_OFN5608_a_cnt_7 Y=n4587
XU4768 NOR2X1 $PINS A=FE_OFN5606_a_cnt_9 B=FE_OFN5605_a_cnt_10 Y=n4569
XU4770 AOI21X1 $PINS A0=N14832 A1=n4301 B0=n4302 Y=n4300
XU4772 INVX1 $PINS A=FE_OFN5605_a_cnt_10 Y=n6669
XU4776 NAND3X1 $PINS A=FE_OFN5608_a_cnt_7 B=FE_OFN5607_a_cnt_8
+ C=FE_OFN5609_a_cnt_6 Y=n4561
XU4779 OAI21XL $PINS A0=N14832 A1=n6687 B0=n4304 Y=n4303
XU4780 XOR2X1 $PINS A=FE_OFN5594_N8543 B=N8545 Y=n4602
XU4784 INVX1 $PINS A=FE_OFN5604_a_cnt_11 Y=n6668
XU4785 INVX1 $PINS A=FE_OFN5607_a_cnt_8 Y=n6674
XU4789 INVX1 $PINS A=FE_OFN5596_N8546 Y=n6685
XU4791 INVXL $PINS A=FE_OFN5520_register_1__16 Y=n5715
XU4797 INVXL $PINS A=FE_OFN5521_register_1__15 Y=n5436
XU4799 INVXL $PINS A=FE_OFN6021_register_1__6 Y=n5498
XU4800 INVXL $PINS A=FE_OFN5526_register_1__7 Y=n5496
XU4802 INVXL $PINS A=FE_OFN5565_register_5__6 Y=n5418
XU4806 INVXL $PINS A=register[7][17] Y=n5861
XU4837 XOR2X4 $PINS A=n5771 B=n6772 Y=r2257/DIFF[15]
XU4838 XOR2X2 $PINS A=n5767 B=FE_DBTN1167_register_0_19 Y=r2257/DIFF[19]
XU4839 NOR2XL $PINS A=FE_OFN6008_register_3__19 B=n5103 Y=n4808
XU4840 XOR2X2 $PINS A=n5659 B=register[7][11] Y=r2240/DIFF[11]
XU4841 OR2X4 $PINS A=n5660 B=FE_OFN262_register_7__10 Y=n5659
XU4842 NOR2XL $PINS A=FE_OFN5591_N610 B=FE_OFN5546_register_3__16 Y=n4822
XU4843 AND2X1 $PINS A=FE_OFN5765_register_3__14 B=FE_OFN5590_N608 Y=n5415
XU4846 XOR2X4 $PINS A=n5780 B=register[0][4] Y=r2257/DIFF[4]
XU4847 AOI22XL $PINS A0=FE_DBTN1_n5754 A1=FE_OFN5516_register_0__18
+ B0=FE_RN_399_0 B1=n5106 Y=n4744
XU4849 NOR2XL $PINS A=FE_OFN6168_N607 B=n5108 Y=n4833
XU4850 OR2X4 $PINS A=FE_OFN5581_register_7__5 B=n5668 Y=n5667
XU4851 NAND4X4 $PINS A=n5549 B=FE_DBTN83_register_5_13
+ C=FE_DBTN82_register_5_12 D=FE_DBTN84_register_5_14 Y=n5553
XU4852 AND2X2 $PINS A=n5545 B=FE_DBTN85_register_5_15 Y=n5549
XU4853 XOR2X4 $PINS A=n5550 B=FE_OFN5558_register_5__19 Y=r2236/DIFF[19]
XU4857 OR2X4 $PINS A=n5557 B=register[5][11] Y=n5556
XU4858 XOR2X1 $PINS A=FE_OFN5775_n5319 B=FE_OFN5549_register_3__10 Y=N614
XU4859 OAI2BB1X1 $PINS A0N=N1693 A1N=n5263 B0=n6740 Y=n6661
XU4860 XOR2X1 $PINS A=n6740 B=N1694 Y=N1730
XU4861 OAI32X4 $PINS A0=n5803 A1=n5802 A2=n5801 B0=N1703 B1=n5800 Y=N1739
XU4862 OR2X4 $PINS A=n5550 B=FE_OFN5558_register_5__19 Y=n284
XU4863 OR2X2 $PINS A=FE_OFN5950_n4451 B=FE_DBTN13_N1253 Y=n5386
XU4864 OR2X2 $PINS A=FE_OFN5950_n4451 B=FE_DBTN12_N1252 Y=n5390
XU4865 OR2X2 $PINS A=FE_OFN5950_n4451 B=FE_DBTN14_N1254 Y=n5398
XU4866 OR2X2 $PINS A=FE_OFN5950_n4451 B=FE_OFN5602_n4937 Y=n5402
XU4867 OR2X2 $PINS A=FE_OFN5950_n4451 B=FE_DBTN90_register_4_4 Y=n5408
XU4869 OR2X2 $PINS A=FE_OFN5950_n4451 B=FE_OFN5826_register_4__5 Y=n5413
XU4870 OR2X2 $PINS A=FE_OFN5950_n4451 B=FE_DBTN1174_register_4_6 Y=n5420
XU4871 OR2X2 $PINS A=FE_OFN5950_n4451 B=FE_DBTN1173_register_4_7 Y=n5424
XU4872 OR2X2 $PINS A=FE_OFN5950_n4451 B=FE_OFN5905_register_4__8 Y=n5428
XU4873 OR2X2 $PINS A=n5051 B=n5329 Y=n5434
XU4874 OR2X2 $PINS A=FE_OFN271_register_2__15 B=n5330 Y=n5433
XU4875 NAND3X1 $PINS A=n5434 B=n5433 C=n5432 Y=n1900
XU4876 OR2X2 $PINS A=n5057 B=n5329 Y=n5440
XU4877 OR2X2 $PINS A=FE_OFN5870_register_2__18 B=n5330 Y=n5439
XU4878 NAND3X1 $PINS A=n5440 B=n5439 C=n5438 Y=n1903
XU4879 OR2X2 $PINS A=n5055 B=FE_OFN5970_n5481 Y=n5443
XU4880 OR2X2 $PINS A=FE_OFN5805_register_2__17 B=n5330 Y=n5442
XU4881 NAND3X1 $PINS A=n5443 B=n5442 C=n5441 Y=n1902
XU4882 OR2X2 $PINS A=n5047 B=n5329 Y=n5451
XU4883 OR2X2 $PINS A=FE_DBTN1157_register_2_13 B=n5330 Y=n5450
XU4884 NAND3X1 $PINS A=n5451 B=n5450 C=n5449 Y=n1898
XU4885 OR2X2 $PINS A=n5043 B=n5329 Y=n5457
XU4886 OR2X2 $PINS A=FE_DBTN121_register_2_11 B=n5330 Y=n5456
XU4887 NAND3X1 $PINS A=n5457 B=n5456 C=n5455 Y=n1896
XU4888 OR2X2 $PINS A=n5039 B=n5329 Y=n5462
XU4889 OR2X2 $PINS A=FE_OFN602_register_2__9 B=n5330 Y=n5461
XU4890 NAND3X1 $PINS A=n5462 B=n5461 C=n5460 Y=n1894
XU4891 OR2X2 $PINS A=n5035 B=n5329 Y=n5468
XU4892 OR2X2 $PINS A=FE_DBTN118_register_2_7 B=n5330 Y=n5467
XU4893 NAND3X2 $PINS A=n5468 B=n5467 C=n5466 Y=n1892
XU4894 OR2X2 $PINS A=FE_OFN5934_n5107 B=FE_DBTN1171_register_3_12 Y=n5513
XU4895 OAI32X1 $PINS A0=n5519 A1=FE_DBTN1171_register_3_12 A2=n5517
+ B0=register[3][12] B1=n5516 Y=n5520
XU4896 XOR3X2 $PINS A=FE_OFN5813_register_3__18 B=FE_OFN5936_N612 C=n5521
+ Y=N622
XU4897 XOR3X2 $PINS A=n4820 B=register[3][17] C=FE_OFN5592_N611 Y=N621
XU4898 XOR3X2 $PINS A=register[3][15] B=FE_OFN5747_N609 C=n5525 Y=N619
XU4899 XOR3X2 $PINS A=n4831 B=FE_OFN5590_N608 C=FE_OFN5765_register_3__14
+ Y=N618
XU4900 XOR3X2 $PINS A=register[3][12] B=FE_OFN5588_N606 C=n5529 Y=N616
XU4901 XOR3X2 $PINS A=FE_OFN5548_register_3__11 B=FE_OFN6039_N1177
+ C=FE_DBTN6_n5396 Y=N615
XU4902 OR2X2 $PINS A=FE_OCPN6261_n5636 B=FE_DBTN1161_register_8_18 Y=n5574
XU4903 OR2X2 $PINS A=FE_OFN6013_n5336 B=n5057 Y=n5573
XU4904 NAND3X1 $PINS A=n5574 B=n5573 C=n5572 Y=n1817
XU4905 OR2X2 $PINS A=n5335 B=FE_DBTN49_register_8_17 Y=n5579
XU4906 OR2X2 $PINS A=FE_OFN6013_n5336 B=n5055 Y=n5578
XU4907 NAND3X1 $PINS A=n5578 B=n5579 C=n5577 Y=n1814
XU4908 OR2X2 $PINS A=FE_OCPN6261_n5636 B=FE_OFN304_register_8__14 Y=n5590
XU4909 OR2X2 $PINS A=FE_OFN6013_n5336 B=n5049 Y=n5589
XU4910 NAND3X1 $PINS A=n5590 B=n5589 C=n5588 Y=n1805
XU4911 OR2X2 $PINS A=FE_OCPN6261_n5636 B=FE_OFN605_register_8__12 Y=n5598
XU4912 OR2X2 $PINS A=FE_OFN6013_n5336 B=n5045 Y=n5597
XU4915 OR2X2 $PINS A=N14471 B=n5674 Y=n5754
XU4917 AOI222X1 $PINS A0=CMF0[21] A1=FE_OFN5644_n4911 B0=n206 B1=n5009 C0=n91
+ C1=n5275 Y=n5688
XU4918 AND2X2 $PINS A=n208 B=n5267 Y=n5699
XU4919 AOI31X2 $PINS A0=n4735 A1=n5694 A2=n5693 B0=n5265 Y=n5698
XU4920 AND2X2 $PINS A=n5273 B=n93 Y=n5697
XU4921 AND2X2 $PINS A=n5916 B=CMF0[19] Y=n5696
XU4923 AND2X2 $PINS A=n209 B=n5267 Y=n5707
XU4924 AOI31X2 $PINS A0=n4744 A1=n5703 A2=n5702 B0=n5265 Y=n5706
XU4925 AND2X2 $PINS A=n5273 B=n94 Y=n5705
XU4926 AND2X2 $PINS A=n5916 B=CMF0[18] Y=n5704
XU4928 AND2X2 $PINS A=n210 B=n5267 Y=n5714
XU4929 OR2X2 $PINS A=n4396 B=FE_OFN5707_register_3__17 Y=n5710
XU4930 AOI31X2 $PINS A0=n4748 A1=n5710 A2=n5709 B0=n5265 Y=n5713
XU4931 AND2X2 $PINS A=n5273 B=n95 Y=n5712
XU4932 AND2X2 $PINS A=n5916 B=CMF0[17] Y=n5711
XU4934 AND2X2 $PINS A=n211 B=n5267 Y=n5721
XU4935 OR2X2 $PINS A=n5755 B=n5715 Y=n5719
XU4936 OR2X2 $PINS A=n5754 B=FE_DBTN146_register_0_16 Y=n5718
XU4937 AOI31X2 $PINS A0=n5719 A1=n5718 A2=n5717 B0=n5265 Y=n5720
XU4939 OAI2BB1X2 $PINS A0N=N1706 A1N=n5795 B0=n5791 Y=n5790
XU4940 OR2X2 $PINS A=n5788 B=N1709 Y=N1746
XU4941 OR2X2 $PINS A=N14585 B=n4371 Y=n5870
XU4942 AND2X2 $PINS A=n5268 B=n113 Y=n5848
XU4943 OR2X2 $PINS A=n5870 B=FE_OFN5550_register_4__19 Y=n5841
XU4944 OR2X2 $PINS A=n5872 B=FE_DBTN89_register_5_19 Y=n5840
XU4945 AOI31X2 $PINS A0=n5841 A1=n5840 A2=n5839 B0=n5266 Y=n5847
XU4946 AND2X2 $PINS A=n5274 B=n73 Y=n5846
XU4947 AND2X2 $PINS A=n5915 B=CMF1[19] Y=n5845
XU4949 AND2X2 $PINS A=n5268 B=n114 Y=n5858
XU4950 OR2X2 $PINS A=n5870 B=FE_OFN5703_register_4__18 Y=n5854
XU4951 OR2X2 $PINS A=n5872 B=FE_DBTN88_register_5_18 Y=n5853
XU4952 AOI31X2 $PINS A0=n5854 A1=n5853 A2=n5852 B0=n5266 Y=n5857
XU4953 AND2X2 $PINS A=n5274 B=n74 Y=n5856
XU4954 AND2X2 $PINS A=n5915 B=CMF1[18] Y=n5855
XU4955 OR4X2 $PINS A=n5858 B=n5857 C=n5856 D=n5855 Y=n1705
XU4956 AND2X2 $PINS A=n115 B=n5268 Y=n5868
XU4957 OR2X2 $PINS A=n5870 B=FE_DBTN0_n6728 Y=n5864
XU4958 OR2X2 $PINS A=n5872 B=FE_DBTN87_register_5_17 Y=n5863
XU4959 AOI31X1 $PINS A0=n5864 A1=n5863 A2=n5862 B0=n5266 Y=n5867
XU4960 AND2X2 $PINS A=n75 B=n5274 Y=n5866
XU4961 AND2X2 $PINS A=n5915 B=CMF1[17] Y=n5865
XU4963 AND2X2 $PINS A=n5268 B=n116 Y=n5880
XU4964 OR2X2 $PINS A=n5870 B=FE_OFN5551_register_4__16 Y=n5876
XU4965 OR2X2 $PINS A=n5872 B=FE_DBTN86_register_5_16 Y=n5875
XU4966 AOI31X1 $PINS A0=n5876 A1=n5875 A2=n5874 B0=n5266 Y=n5879
XU4967 AND2X2 $PINS A=n5274 B=n76 Y=n5878
XU4968 AND2X2 $PINS A=n5915 B=CMF1[16] Y=n5877
XU4970 AOI222X4 $PINS A0=n123 A1=FE_OFN5978_n5340 B0=FE_OFN335_register_4__9
+ B1=n5341 C0=FE_OFN5563_register_5__9 C1=n5342 Y=n5893
XU4972 AOI222X4 $PINS A0=n126 A1=FE_OFN5978_n5340 B0=register[4][6] B1=n5341
+ C0=n5342 C1=FE_OFN5565_register_5__6 Y=n5899
XU4973 AOI222X4 $PINS A0=CMF0[26] A1=n4256 B0=CMF1[10] B1=n5239
+ C0=FE_OFN5616_CMF0_10 C1=n5354 Y=n4281
XU4974 AOI222X4 $PINS A0=CMF0[27] A1=n4256 B0=CMF1[11] B1=n5239
+ C0=FE_OFN5615_CMF0_11 C1=n5354 Y=n4279
XU4975 AOI222X4 $PINS A0=CMF0[28] A1=n4256 B0=CMF1[12] B1=n5239
+ C0=FE_OFN5614_CMF0_12 C1=n5354 Y=n4277
XU4976 AOI222X4 $PINS A0=CMF0[29] A1=n4256 B0=CMF1[13] B1=n5239
+ C0=FE_OFN5613_CMF0_13 C1=n5354 Y=n4275
XU4977 AOI222X4 $PINS A0=CMF0[30] A1=n4256 B0=CMF1[14] B1=n5239
+ C0=FE_OFN5612_CMF0_14 C1=n5354 Y=n4273
XU4978 AOI222X4 $PINS A0=CMF0[31] A1=n4256 B0=CMF1[15] B1=n5239
+ C0=FE_OFN5611_CMF0_15 C1=n5354 Y=n4271
XU4979 AOI222X4 $PINS A0=n5111 A1=n4256 B0=CMF1[16] B1=n5239 C0=CMF0[16]
+ C1=n5354 Y=n4269
XU4980 AOI222X4 $PINS A0=n5112 A1=n4256 B0=CMF1[17] B1=n5239 C0=CMF0[17]
+ C1=n5354 Y=n4267
XU4981 AOI222X4 $PINS A0=n5118 A1=n4256 B0=CMF1[18] B1=n5239 C0=CMF0[18]
+ C1=n5354 Y=n4265
XU4982 AOI222X4 $PINS A0=n4256 A1=n5117 B0=n5239 B1=CMF1[19] C0=n5354
+ C1=CMF0[19] Y=n4263
Xregister_reg[6][0] SDFFRX4 $PINS SI=register[6][5] SE=FE_OFN5514_i_SCAN_EN
+ D=n1762 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=n5321
Xregister_reg[0][15] SDFFRX4 $PINS SI=FE_OFN5536_register_2__12
+ SE=FE_OFN5512_i_SCAN_EN D=n1880 CK=CTS_1 RN=FE_OFN5634_FE_DBTN149_i_reset
+ Q=n6772 QN=n6773
Xregister_reg[6][2] SDFFRX4 $PINS SI=FE_OFN5630_CMF1_2 SE=FE_OFN5514_i_SCAN_EN
+ D=n1768 CK=CTS_5 RN=FE_OFN5633_FE_DBTN149_i_reset Q=n4963
Xregister_reg[4][17] SDFFRXL $PINS SI=register[4][15] SE=FE_OFN5509_i_SCAN_EN
+ D=n1860 CK=CTS_5 RN=FE_OFN5943_n Q=n6728
XU3496 XNOR2X2 $PINS A=n5667 B=register[7][6] Y=n6739
XU3500 OR2X2 $PINS A=N1693 B=n5263 Y=n6740
XU3703 NAND2BX2 $PINS AN=n5818 B=N1699 Y=n4893
XU3728 XOR2X2 $PINS A=FE_DBTN26_N1697 B=n5261 Y=N1733
XU3800 XNOR2X1 $PINS A=n5773 B=register[0][13] Y=n6745
XU4914 NOR2X1 $PINS A=register[7][8] B=n5665 Y=n6751
XU5664 OR2X2 $PINS A=n4398 B=n4635 Y=n6752
XU5665 INVX1 $PINS A=n6752 Y=n4386
XU5668 NOR2X2 $PINS A=n4394 B=n4909 Y=n6755
XU5670 XNOR2X4 $PINS A=n5651 B=FE_OFN5700_register_7__18 Y=r2240/DIFF[18]
XU5677 OR2X2 $PINS A=FE_OFN6093_n4911 B=n5835 Y=n6762
XU5679 OAI222XL $PINS A0=FE_OCPN6243_n5834 A1=n6765 B0=n6766 B1=FE_OFN608_n5011
+ C0=n6768 C1=FE_OFN6082_n5272 Y=n6763
XU5681 INVX1 $PINS A=CMF1[27] Y=n6765
XU5684 INVX1 $PINS A=n65 Y=n6768
XU5688 AND2X2 $PINS A=FE_OFN5796_n4440 B=n5349 Y=n6771
XU5691 INVX1 $PINS A=n5872 Y=n6774
XU5692 AND2X4 $PINS A=n4632 B=n5260 Y=n6775
XU5694 NOR2BX4 $PINS AN=n5834 B=n5835 Y=n5011
.ENDS

.SUBCKT CHIP clk reset busy ready iaddr[11] iaddr[10] iaddr[9] iaddr[8]
+ iaddr[7] iaddr[6] iaddr[5] iaddr[4] iaddr[3] iaddr[2] iaddr[1] iaddr[0]
+ idata[19] idata[18] idata[17] idata[16] idata[15] idata[14] idata[13]
+ idata[12] idata[11] idata[10] idata[9] idata[8] idata[7] idata[6] idata[5]
+ idata[4] idata[3] idata[2] idata[1] idata[0] cwr caddr_wr[11] caddr_wr[10]
+ caddr_wr[9] caddr_wr[8] caddr_wr[7] caddr_wr[6] caddr_wr[5] caddr_wr[4]
+ caddr_wr[3] caddr_wr[2] caddr_wr[1] caddr_wr[0] cdata_wr[19] cdata_wr[18]
+ cdata_wr[17] cdata_wr[16] cdata_wr[15] cdata_wr[14] cdata_wr[13] cdata_wr[12]
+ cdata_wr[11] cdata_wr[10] cdata_wr[9] cdata_wr[8] cdata_wr[7] cdata_wr[6]
+ cdata_wr[5] cdata_wr[4] cdata_wr[3] cdata_wr[2] cdata_wr[1] cdata_wr[0] crd
+ caddr_rd[11] caddr_rd[10] caddr_rd[9] caddr_rd[8] caddr_rd[7] caddr_rd[6]
+ caddr_rd[5] caddr_rd[4] caddr_rd[3] caddr_rd[2] caddr_rd[1] caddr_rd[0]
+ cdata_rd[19] cdata_rd[18] cdata_rd[17] cdata_rd[16] cdata_rd[15] cdata_rd[14]
+ cdata_rd[13] cdata_rd[12] cdata_rd[11] cdata_rd[10] cdata_rd[9] cdata_rd[8]
+ cdata_rd[7] cdata_rd[6] cdata_rd[5] cdata_rd[4] cdata_rd[3] cdata_rd[2]
+ cdata_rd[1] cdata_rd[0] csel[2] csel[1] csel[0] SCAN_IN SCAN_OUT SCAN_EN
XCONV CONV $PINS clk=i_clk reset=i_reset busy=i_busy ready=i_ready
+ iaddr[11]=i_iaddr[11] iaddr[10]=i_iaddr[10] iaddr[9]=i_iaddr[9]
+ iaddr[8]=i_iaddr[8] iaddr[7]=i_iaddr[7] iaddr[6]=i_iaddr[6] iaddr[5]=i_iaddr[5]
+ iaddr[4]=i_iaddr[4] iaddr[3]=i_iaddr[3] iaddr[2]=i_iaddr[2] iaddr[1]=i_iaddr[1]
+ iaddr[0]=i_iaddr[0] idata[19]=i_idata[19] idata[18]=i_idata[18]
+ idata[17]=i_idata[17] idata[16]=i_idata[16] idata[15]=i_idata[15]
+ idata[14]=i_idata[14] idata[13]=i_idata[13] idata[12]=i_idata[12]
+ idata[11]=i_idata[11] idata[10]=i_idata[10] idata[9]=i_idata[9]
+ idata[8]=i_idata[8] idata[7]=i_idata[7] idata[6]=i_idata[6] idata[5]=i_idata[5]
+ idata[4]=i_idata[4] idata[3]=i_idata[3] idata[2]=i_idata[2] idata[1]=i_idata[1]
+ idata[0]=i_idata[0] cwr=i_cwr caddr_wr[11]=i_caddr_wr[11]
+ caddr_wr[10]=i_caddr_wr[10] caddr_wr[9]=i_caddr_wr[9] caddr_wr[8]=i_caddr_wr[8]
+ caddr_wr[7]=i_caddr_wr[7] caddr_wr[6]=i_caddr_wr[6] caddr_wr[5]=i_caddr_wr[5]
+ caddr_wr[4]=i_caddr_wr[4] caddr_wr[3]=i_caddr_wr[3] caddr_wr[2]=i_caddr_wr[2]
+ caddr_wr[1]=i_caddr_wr[1] caddr_wr[0]=i_caddr_wr[0] cdata_wr[19]=i_cdata_wr[19]
+ cdata_wr[18]=i_cdata_wr[18] cdata_wr[17]=i_cdata_wr[17]
+ cdata_wr[16]=i_cdata_wr[16] cdata_wr[15]=i_cdata_wr[15]
+ cdata_wr[14]=i_cdata_wr[14] cdata_wr[13]=i_cdata_wr[13]
+ cdata_wr[12]=i_cdata_wr[12] cdata_wr[11]=i_cdata_wr[11]
+ cdata_wr[10]=i_cdata_wr[10] cdata_wr[9]=i_cdata_wr[9] cdata_wr[8]=i_cdata_wr[8]
+ cdata_wr[7]=i_cdata_wr[7] cdata_wr[6]=i_cdata_wr[6] cdata_wr[5]=i_cdata_wr[5]
+ cdata_wr[4]=i_cdata_wr[4] cdata_wr[3]=i_cdata_wr[3] cdata_wr[2]=i_cdata_wr[2]
+ cdata_wr[1]=i_cdata_wr[1] cdata_wr[0]=i_cdata_wr[0] crd=i_crd
+ caddr_rd[11]=i_caddr_rd[11] caddr_rd[10]=i_caddr_rd[10]
+ caddr_rd[9]=i_caddr_rd[9] caddr_rd[8]=i_caddr_rd[8] caddr_rd[7]=i_caddr_rd[7]
+ caddr_rd[6]=i_caddr_rd[6] caddr_rd[5]=i_caddr_rd[5] caddr_rd[4]=i_caddr_rd[4]
+ caddr_rd[3]=i_caddr_rd[3] caddr_rd[2]=i_caddr_rd[2] caddr_rd[1]=i_caddr_rd[1]
+ caddr_rd[0]=i_caddr_rd[0] cdata_rd[19]=i_cdata_rd[19]
+ cdata_rd[18]=i_cdata_rd[18] cdata_rd[17]=i_cdata_rd[17]
+ cdata_rd[16]=i_cdata_rd[16] cdata_rd[15]=i_cdata_rd[15]
+ cdata_rd[14]=i_cdata_rd[14] cdata_rd[13]=i_cdata_rd[13]
+ cdata_rd[12]=i_cdata_rd[12] cdata_rd[11]=i_cdata_rd[11]
+ cdata_rd[10]=i_cdata_rd[10] cdata_rd[9]=i_cdata_rd[9] cdata_rd[8]=i_cdata_rd[8]
+ cdata_rd[7]=i_cdata_rd[7] cdata_rd[6]=i_cdata_rd[6] cdata_rd[5]=i_cdata_rd[5]
+ cdata_rd[4]=i_cdata_rd[4] cdata_rd[3]=i_cdata_rd[3] cdata_rd[2]=i_cdata_rd[2]
+ cdata_rd[1]=i_cdata_rd[1] cdata_rd[0]=i_cdata_rd[0] csel[2]=i_csel[2]
+ csel[1]=i_csel[1] csel[0]=i_csel[0] SCAN_IN=i_SCAN_IN SCAN_OUT=i_SCAN_OUT
+ SCAN_EN=i_SCAN_EN
Xipad_clk PDIDGZ $PINS PAD=clk C=i_clk
Xipad_reset PDIDGZ $PINS PAD=reset C=i_reset
Xipad_ready PDIDGZ $PINS PAD=ready C=i_ready
Xipad_idata0 PDIDGZ $PINS PAD=idata[0] C=i_idata[0]
Xipad_idata1 PDIDGZ $PINS PAD=idata[1] C=i_idata[1]
Xipad_idata2 PDIDGZ $PINS PAD=idata[2] C=i_idata[2]
Xipad_idata3 PDIDGZ $PINS PAD=idata[3] C=i_idata[3]
Xipad_idata4 PDIDGZ $PINS PAD=idata[4] C=i_idata[4]
Xipad_idata5 PDIDGZ $PINS PAD=idata[5] C=i_idata[5]
Xipad_idata6 PDIDGZ $PINS PAD=idata[6] C=i_idata[6]
Xipad_idata7 PDIDGZ $PINS PAD=idata[7] C=i_idata[7]
Xipad_idata8 PDIDGZ $PINS PAD=idata[8] C=i_idata[8]
Xipad_idata9 PDIDGZ $PINS PAD=idata[9] C=i_idata[9]
Xipad_idata10 PDIDGZ $PINS PAD=idata[10] C=i_idata[10]
Xipad_idata11 PDIDGZ $PINS PAD=idata[11] C=i_idata[11]
Xipad_idata12 PDIDGZ $PINS PAD=idata[12] C=i_idata[12]
Xipad_idata13 PDIDGZ $PINS PAD=idata[13] C=i_idata[13]
Xipad_idata14 PDIDGZ $PINS PAD=idata[14] C=i_idata[14]
Xipad_idata15 PDIDGZ $PINS PAD=idata[15] C=i_idata[15]
Xipad_idata16 PDIDGZ $PINS PAD=idata[16] C=i_idata[16]
Xipad_idata17 PDIDGZ $PINS PAD=idata[17] C=i_idata[17]
Xipad_idata18 PDIDGZ $PINS PAD=idata[18] C=i_idata[18]
Xipad_idata19 PDIDGZ $PINS PAD=idata[19] C=i_idata[19]
Xipad_cdata_rd0 PDIDGZ $PINS PAD=cdata_rd[0] C=i_cdata_rd[0]
Xipad_cdata_rd1 PDIDGZ $PINS PAD=cdata_rd[1] C=i_cdata_rd[1]
Xipad_cdata_rd2 PDIDGZ $PINS PAD=cdata_rd[2] C=i_cdata_rd[2]
Xipad_cdata_rd3 PDIDGZ $PINS PAD=cdata_rd[3] C=i_cdata_rd[3]
Xipad_cdata_rd4 PDIDGZ $PINS PAD=cdata_rd[4] C=i_cdata_rd[4]
Xipad_cdata_rd5 PDIDGZ $PINS PAD=cdata_rd[5] C=i_cdata_rd[5]
Xipad_cdata_rd6 PDIDGZ $PINS PAD=cdata_rd[6] C=i_cdata_rd[6]
Xipad_cdata_rd7 PDIDGZ $PINS PAD=cdata_rd[7] C=i_cdata_rd[7]
Xipad_cdata_rd8 PDIDGZ $PINS PAD=cdata_rd[8] C=i_cdata_rd[8]
Xipad_cdata_rd9 PDIDGZ $PINS PAD=cdata_rd[9] C=i_cdata_rd[9]
Xipad_cdata_rd10 PDIDGZ $PINS PAD=cdata_rd[10] C=i_cdata_rd[10]
Xipad_cdata_rd11 PDIDGZ $PINS PAD=cdata_rd[11] C=i_cdata_rd[11]
Xipad_cdata_rd12 PDIDGZ $PINS PAD=cdata_rd[12] C=i_cdata_rd[12]
Xipad_cdata_rd13 PDIDGZ $PINS PAD=cdata_rd[13] C=i_cdata_rd[13]
Xipad_cdata_rd14 PDIDGZ $PINS PAD=cdata_rd[14] C=i_cdata_rd[14]
Xipad_cdata_rd15 PDIDGZ $PINS PAD=cdata_rd[15] C=i_cdata_rd[15]
Xipad_cdata_rd16 PDIDGZ $PINS PAD=cdata_rd[16] C=i_cdata_rd[16]
Xipad_cdata_rd17 PDIDGZ $PINS PAD=cdata_rd[17] C=i_cdata_rd[17]
Xipad_cdata_rd18 PDIDGZ $PINS PAD=cdata_rd[18] C=i_cdata_rd[18]
Xipad_cdata_rd19 PDIDGZ $PINS PAD=cdata_rd[19] C=i_cdata_rd[19]
Xipad_SCAN_IN PDIDGZ $PINS PAD=SCAN_IN C=i_SCAN_IN
Xipad_SCAN_EN PDIDGZ $PINS PAD=SCAN_EN C=i_SCAN_EN
Xopad_SCAN_OUT PDO12CDG $PINS I=i_iaddr[11] PAD=SCAN_OUT
Xopad_busy PDO12CDG $PINS I=i_busy PAD=busy
Xopad_iaddr0 PDO12CDG $PINS I=i_iaddr[0] PAD=iaddr[0]
Xopad_iaddr1 PDO12CDG $PINS I=i_iaddr[1] PAD=iaddr[1]
Xopad_iaddr2 PDO12CDG $PINS I=i_iaddr[2] PAD=iaddr[2]
Xopad_iaddr3 PDO12CDG $PINS I=i_iaddr[3] PAD=iaddr[3]
Xopad_iaddr4 PDO12CDG $PINS I=i_iaddr[4] PAD=iaddr[4]
Xopad_iaddr5 PDO12CDG $PINS I=i_iaddr[5] PAD=iaddr[5]
Xopad_iaddr6 PDO12CDG $PINS I=i_iaddr[6] PAD=iaddr[6]
Xopad_iaddr7 PDO12CDG $PINS I=i_iaddr[7] PAD=iaddr[7]
Xopad_iaddr8 PDO12CDG $PINS I=i_iaddr[8] PAD=iaddr[8]
Xopad_iaddr9 PDO12CDG $PINS I=i_iaddr[9] PAD=iaddr[9]
Xopad_iaddr10 PDO12CDG $PINS I=i_iaddr[10] PAD=iaddr[10]
Xopad_iaddr11 PDO12CDG $PINS I=i_iaddr[11] PAD=iaddr[11]
Xopad_cwr PDO12CDG $PINS I=i_cwr PAD=cwr
Xopad_caddr_wr0 PDO12CDG $PINS I=i_caddr_wr[0] PAD=caddr_wr[0]
Xopad_caddr_wr1 PDO12CDG $PINS I=i_caddr_wr[1] PAD=caddr_wr[1]
Xopad_caddr_wr2 PDO12CDG $PINS I=i_caddr_wr[2] PAD=caddr_wr[2]
Xopad_caddr_wr3 PDO12CDG $PINS I=i_caddr_wr[3] PAD=caddr_wr[3]
Xopad_caddr_wr4 PDO12CDG $PINS I=i_caddr_wr[4] PAD=caddr_wr[4]
Xopad_caddr_wr5 PDO12CDG $PINS I=i_caddr_wr[5] PAD=caddr_wr[5]
Xopad_caddr_wr6 PDO12CDG $PINS I=i_caddr_wr[6] PAD=caddr_wr[6]
Xopad_caddr_wr7 PDO12CDG $PINS I=i_caddr_wr[7] PAD=caddr_wr[7]
Xopad_caddr_wr8 PDO12CDG $PINS I=i_caddr_wr[8] PAD=caddr_wr[8]
Xopad_caddr_wr9 PDO12CDG $PINS I=i_caddr_wr[9] PAD=caddr_wr[9]
Xopad_caddr_wr10 PDO12CDG $PINS I=i_caddr_wr[10] PAD=caddr_wr[10]
Xopad_caddr_wr11 PDO12CDG $PINS I=i_caddr_wr[11] PAD=caddr_wr[11]
Xopad_cdata_wr0 PDO12CDG $PINS I=i_cdata_wr[0] PAD=cdata_wr[0]
Xopad_cdata_wr1 PDO12CDG $PINS I=i_cdata_wr[1] PAD=cdata_wr[1]
Xopad_cdata_wr2 PDO12CDG $PINS I=i_cdata_wr[2] PAD=cdata_wr[2]
Xopad_cdata_wr3 PDO12CDG $PINS I=i_cdata_wr[3] PAD=cdata_wr[3]
Xopad_cdata_wr4 PDO12CDG $PINS I=i_cdata_wr[4] PAD=cdata_wr[4]
Xopad_cdata_wr5 PDO12CDG $PINS I=i_cdata_wr[5] PAD=cdata_wr[5]
Xopad_cdata_wr6 PDO12CDG $PINS I=i_cdata_wr[6] PAD=cdata_wr[6]
Xopad_cdata_wr7 PDO12CDG $PINS I=i_cdata_wr[7] PAD=cdata_wr[7]
Xopad_cdata_wr8 PDO12CDG $PINS I=i_cdata_wr[8] PAD=cdata_wr[8]
Xopad_cdata_wr9 PDO12CDG $PINS I=i_cdata_wr[9] PAD=cdata_wr[9]
Xopad_cdata_wr10 PDO12CDG $PINS I=i_cdata_wr[10] PAD=cdata_wr[10]
Xopad_cdata_wr11 PDO12CDG $PINS I=i_cdata_wr[11] PAD=cdata_wr[11]
Xopad_cdata_wr12 PDO12CDG $PINS I=i_cdata_wr[12] PAD=cdata_wr[12]
Xopad_cdata_wr13 PDO12CDG $PINS I=i_cdata_wr[13] PAD=cdata_wr[13]
Xopad_cdata_wr14 PDO12CDG $PINS I=i_cdata_wr[14] PAD=cdata_wr[14]
Xopad_cdata_wr15 PDO12CDG $PINS I=i_cdata_wr[15] PAD=cdata_wr[15]
Xopad_cdata_wr16 PDO12CDG $PINS I=i_cdata_wr[16] PAD=cdata_wr[16]
Xopad_cdata_wr17 PDO12CDG $PINS I=i_cdata_wr[17] PAD=cdata_wr[17]
Xopad_cdata_wr18 PDO12CDG $PINS I=i_cdata_wr[18] PAD=cdata_wr[18]
Xopad_cdata_wr19 PDO12CDG $PINS I=i_cdata_wr[19] PAD=cdata_wr[19]
Xopad_crd PDO12CDG $PINS I=i_crd PAD=crd
Xopad_caddr_rd0 PDO12CDG $PINS I=i_caddr_rd[0] PAD=caddr_rd[0]
Xopad_caddr_rd1 PDO12CDG $PINS I=i_caddr_rd[1] PAD=caddr_rd[1]
Xopad_caddr_rd2 PDO12CDG $PINS I=i_caddr_rd[2] PAD=caddr_rd[2]
Xopad_caddr_rd3 PDO12CDG $PINS I=i_caddr_rd[3] PAD=caddr_rd[3]
Xopad_caddr_rd4 PDO12CDG $PINS I=i_caddr_rd[4] PAD=caddr_rd[4]
Xopad_caddr_rd5 PDO12CDG $PINS I=i_caddr_rd[5] PAD=caddr_rd[5]
Xopad_caddr_rd6 PDO12CDG $PINS I=i_caddr_rd[6] PAD=caddr_rd[6]
Xopad_caddr_rd7 PDO12CDG $PINS I=i_caddr_rd[7] PAD=caddr_rd[7]
Xopad_caddr_rd8 PDO12CDG $PINS I=i_caddr_rd[8] PAD=caddr_rd[8]
Xopad_caddr_rd9 PDO12CDG $PINS I=i_caddr_rd[9] PAD=caddr_rd[9]
Xopad_caddr_rd10 PDO12CDG $PINS I=i_caddr_rd[10] PAD=caddr_rd[10]
Xopad_caddr_rd11 PDO12CDG $PINS I=i_caddr_rd[11] PAD=caddr_rd[11]
Xopad_csel0 PDO12CDG $PINS I=i_csel[0] PAD=csel[0]
Xopad_csel1 PDO12CDG $PINS I=i_csel[1] PAD=csel[1]
Xopad_csel2 PDO12CDG $PINS I=i_csel[2] PAD=csel[2]
.ENDS
.GLOBAL VDD
.GLOBAL VSS
